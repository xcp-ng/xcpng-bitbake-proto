
PN = "qt6-qt3d"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qt3d qt6-qt3d-devel qt6-qt3d-examples qt6-qt3d-tests"


URI_qt6-qt3d = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qt3d-6.8.1-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:qt6-qt3d = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) libm.so.6()(64bit) ( ) libgcc_s.so.1()(64bit) ( ) libgcc_s.so.1(GCC_3.0)(64bit) ( ) libm.so.6(GLIBC_2.2.5)(64bit) ( ) libstdc++.so.6()(64bit) ( ) libstdc++.so.6(CXXABI_1.3)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4)(64bit) ( ) libm.so.6(GLIBC_2.29)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.9)(64bit) ( ) libz.so.1()(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.30)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.21)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.11)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.29)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.20)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.32)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.9)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.15)(64bit) ( ) libm.so.6(GLIBC_2.38)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.18)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.14)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.26)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.5)(64bit) ( ) libm.so.6(GLIBC_2.27)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.8)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.15)(64bit) ( ) libm.so.6(GLIBC_2.35)(64bit) ( ) libQt6Core.so.6()(64bit) ( ) libQt6Core.so.6(Qt_6)(64bit) ( ) libQt6Core.so.6(Qt_6.8)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.7)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.19)(64bit) ( ) libQt6Gui.so.6()(64bit) ( ) libQt6Gui.so.6(Qt_6)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.13)(64bit) ( ) libQt6Core.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.3)(64bit) ( ) libQt6Network.so.6()(64bit) ( ) libQt6Qml.so.6()(64bit) ( ) libQt6Qml.so.6(Qt_6)(64bit) ( ) libQt6Network.so.6(Qt_6)(64bit) ( ) libQt6Quick.so.6()(64bit) ( ) libQt6Gui.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt6Quick.so.6(Qt_6)(64bit) ( ) libQt6OpenGL.so.6()(64bit) ( ) libQt6Quick.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt6OpenGL.so.6(Qt_6)(64bit) ( ) libQt6Qml.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt6Concurrent.so.6()(64bit) ( ) libQt6ShaderTools.so.6()(64bit) ( ) libQt6QmlModels.so.6()(64bit) ( ) libQt6ShaderTools.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt6Concurrent.so.6(Qt_6)(64bit) ( ) libQt6QmlModels.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) qt6-qtbase(x86-64) ( =  6.8.1) qt6-qtimageformats(x86-64) ( >=  6.8.1)"
RPROVIDES:qt6-qt3d = "libQt63DAnimation.so.6()(64bit) ( ) libQt63DCore.so.6()(64bit) ( ) libQt63DExtras.so.6()(64bit) ( ) libQt63DInput.so.6()(64bit) ( ) libQt63DLogic.so.6()(64bit) ( ) libQt63DQuick.so.6()(64bit) ( ) libQt63DQuickAnimation.so.6()(64bit) ( ) libQt63DQuickExtras.so.6()(64bit) ( ) libQt63DQuickInput.so.6()(64bit) ( ) libQt63DQuickRender.so.6()(64bit) ( ) libQt63DQuickScene2D.so.6()(64bit) ( ) libQt63DQuickScene3D.so.6()(64bit) ( ) libQt63DRender.so.6()(64bit) ( ) libQt63DAnimation.so.6(NonQt)(64bit) ( ) libQt63DAnimation.so.6(Qt_6)(64bit) ( ) libQt63DAnimation.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DCore.so.6(NonQt)(64bit) ( ) libQt63DCore.so.6(Qt_6)(64bit) ( ) libQt63DCore.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DExtras.so.6(NonQt)(64bit) ( ) libQt63DExtras.so.6(Qt_6)(64bit) ( ) libQt63DExtras.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DInput.so.6(NonQt)(64bit) ( ) libQt63DInput.so.6(Qt_6)(64bit) ( ) libQt63DInput.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DLogic.so.6(NonQt)(64bit) ( ) libQt63DLogic.so.6(Qt_6)(64bit) ( ) libQt63DLogic.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DQuick.so.6(NonQt)(64bit) ( ) libQt63DQuick.so.6(Qt_6)(64bit) ( ) libQt63DQuick.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DQuickAnimation.so.6(NonQt)(64bit) ( ) libQt63DQuickAnimation.so.6(Qt_6)(64bit) ( ) libQt63DQuickAnimation.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DQuickExtras.so.6(NonQt)(64bit) ( ) libQt63DQuickExtras.so.6(Qt_6)(64bit) ( ) libQt63DQuickExtras.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DQuickInput.so.6(NonQt)(64bit) ( ) libQt63DQuickInput.so.6(Qt_6)(64bit) ( ) libQt63DQuickInput.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DQuickRender.so.6(NonQt)(64bit) ( ) libQt63DQuickRender.so.6(Qt_6)(64bit) ( ) libQt63DQuickRender.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DQuickScene2D.so.6(NonQt)(64bit) ( ) libQt63DQuickScene2D.so.6(Qt_6)(64bit) ( ) libQt63DQuickScene2D.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DQuickScene3D.so.6(NonQt)(64bit) ( ) libQt63DQuickScene3D.so.6(Qt_6)(64bit) ( ) libQt63DQuickScene3D.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DRender.so.6(NonQt)(64bit) ( ) libQt63DRender.so.6(Qt_6)(64bit) ( ) libQt63DRender.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libassimpsceneimport.so()(64bit) ( ) libassimpsceneimport.so(NonQt)(64bit) ( ) libassimpsceneimport.so(Qt_6)(64bit) ( ) libassimpsceneimport.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libdefaultgeometryloader.so()(64bit) ( ) libdefaultgeometryloader.so(NonQt)(64bit) ( ) libdefaultgeometryloader.so(Qt_6)(64bit) ( ) libdefaultgeometryloader.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libgltfgeometryloader.so()(64bit) ( ) libgltfgeometryloader.so(NonQt)(64bit) ( ) libgltfgeometryloader.so(Qt_6)(64bit) ( ) libgltfgeometryloader.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libgltfsceneexport.so()(64bit) ( ) libgltfsceneexport.so(NonQt)(64bit) ( ) libgltfsceneexport.so(Qt_6)(64bit) ( ) libgltfsceneexport.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libgltfsceneimport.so()(64bit) ( ) libgltfsceneimport.so(NonQt)(64bit) ( ) libgltfsceneimport.so(Qt_6)(64bit) ( ) libgltfsceneimport.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libopenglrenderer.so()(64bit) ( ) libopenglrenderer.so(NonQt)(64bit) ( ) libopenglrenderer.so(Qt_6)(64bit) ( ) libopenglrenderer.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libqtquickscene2dplugin.so()(64bit) ( ) libqtquickscene2dplugin.so(NonQt)(64bit) ( ) libqtquickscene2dplugin.so(Qt_6)(64bit) ( ) libqtquickscene2dplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libqtquickscene3dplugin.so()(64bit) ( ) libqtquickscene3dplugin.so(NonQt)(64bit) ( ) libqtquickscene3dplugin.so(Qt_6)(64bit) ( ) libqtquickscene3dplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libquick3danimationplugin.so()(64bit) ( ) libquick3danimationplugin.so(NonQt)(64bit) ( ) libquick3danimationplugin.so(Qt_6)(64bit) ( ) libquick3danimationplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libquick3dcoreplugin.so()(64bit) ( ) libquick3dcoreplugin.so(NonQt)(64bit) ( ) libquick3dcoreplugin.so(Qt_6)(64bit) ( ) libquick3dcoreplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libquick3dextrasplugin.so()(64bit) ( ) libquick3dextrasplugin.so(NonQt)(64bit) ( ) libquick3dextrasplugin.so(Qt_6)(64bit) ( ) libquick3dextrasplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libquick3dinputplugin.so()(64bit) ( ) libquick3dinputplugin.so(NonQt)(64bit) ( ) libquick3dinputplugin.so(Qt_6)(64bit) ( ) libquick3dinputplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libquick3dlogicplugin.so()(64bit) ( ) libquick3dlogicplugin.so(NonQt)(64bit) ( ) libquick3dlogicplugin.so(Qt_6)(64bit) ( ) libquick3dlogicplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libquick3drenderplugin.so()(64bit) ( ) libquick3drenderplugin.so(NonQt)(64bit) ( ) libquick3drenderplugin.so(Qt_6)(64bit) ( ) libquick3drenderplugin.so(Qt_6.8_PRIVATE_API)(64bit) ( ) librhirenderer.so()(64bit) ( ) librhirenderer.so(NonQt)(64bit) ( ) librhirenderer.so(Qt_6)(64bit) ( ) librhirenderer.so(Qt_6.8_PRIVATE_API)(64bit) ( ) libscene2d.so()(64bit) ( ) libscene2d.so(NonQt)(64bit) ( ) libscene2d.so(Qt_6)(64bit) ( ) libscene2d.so(Qt_6.8_PRIVATE_API)(64bit) ( ) qt6qml(Qt3D.Animation) ( ) qt6qml(Qt3D.Core) ( ) qt6qml(Qt3D.Extras) ( ) qt6qml(Qt3D.Input) ( ) qt6qml(Qt3D.Logic) ( ) qt6qml(Qt3D.Render) ( ) qt6qml(QtQuick.Scene2D) ( ) qt6qml(QtQuick.Scene3D) ( ) qt6-qt3d(x86-64) ( =  6.8.1-1.el10) qt6-qt3d ( =  6.8.1-1.el10)"

URI_qt6-qt3d-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qt3d-devel-6.8.1-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:qt6-qt3d-devel = "/usr/bin/pkg-config ( ) cmake-filesystem(x86-64) ( ) qt6-qtbase-devel(x86-64) ( ) pkgconfig(Qt6Core) ( ) pkgconfig(Qt6Gui) ( ) pkgconfig(Qt6Qml) ( ) pkgconfig(Qt6Network) ( ) pkgconfig(Qt6Quick) ( ) pkgconfig(Qt6OpenGL) ( ) pkgconfig(Qt6Concurrent) ( ) libQt63DAnimation.so.6()(64bit) ( ) libQt63DCore.so.6()(64bit) ( ) libQt63DExtras.so.6()(64bit) ( ) libQt63DInput.so.6()(64bit) ( ) libQt63DLogic.so.6()(64bit) ( ) libQt63DQuick.so.6()(64bit) ( ) libQt63DQuickAnimation.so.6()(64bit) ( ) libQt63DQuickExtras.so.6()(64bit) ( ) libQt63DQuickInput.so.6()(64bit) ( ) libQt63DQuickRender.so.6()(64bit) ( ) libQt63DQuickScene2D.so.6()(64bit) ( ) libQt63DQuickScene3D.so.6()(64bit) ( ) libQt63DRender.so.6()(64bit) ( ) pkgconfig(Qt63DAnimation) ( ) pkgconfig(Qt63DCore) ( ) pkgconfig(Qt63DExtras) ( ) pkgconfig(Qt63DInput) ( ) pkgconfig(Qt63DLogic) ( ) pkgconfig(Qt63DQuick) ( ) pkgconfig(Qt63DRender) ( ) qt6-qt3d(x86-64) ( =  6.8.1-1.el10)"
RPROVIDES:qt6-qt3d-devel = "cmake(Qt3DTests) ( ) cmake(Qt63DAnimation) ( ) cmake(Qt63DCore) ( ) cmake(Qt63DExtras) ( ) cmake(Qt63DInput) ( ) cmake(Qt63DLogic) ( ) cmake(Qt63DQuick) ( ) cmake(Qt63DQuickAnimation) ( ) cmake(Qt63DQuickExtras) ( ) cmake(Qt63DQuickInput) ( ) cmake(Qt63DQuickRender) ( ) cmake(Qt63DQuickScene2D) ( ) cmake(Qt63DQuickScene3D) ( ) cmake(Qt63DRender) ( ) cmake(Qt6AssimpSceneImportPlugin) ( ) cmake(Qt6DefaultGeometryLoaderPlugin) ( ) cmake(Qt6GLTFGeometryLoaderPlugin) ( ) cmake(Qt6GLTFSceneExportPlugin) ( ) cmake(Qt6GLTFSceneImportPlugin) ( ) cmake(Qt6OpenGLRendererPlugin) ( ) cmake(Qt6RhiRendererPlugin) ( ) cmake(Qt6Scene2DPlugin) ( ) cmake(Qt6qtquickscene2dplugin) ( ) cmake(Qt6qtquickscene3dplugin) ( ) cmake(Qt6quick3danimationplugin) ( ) cmake(Qt6quick3dcoreplugin) ( ) cmake(Qt6quick3dextrasplugin) ( ) cmake(Qt6quick3dinputplugin) ( ) cmake(Qt6quick3dlogicplugin) ( ) cmake(Qt6quick3drenderplugin) ( ) cmake(qt3dtests) ( ) cmake(qt63danimation) ( ) cmake(qt63dcore) ( ) cmake(qt63dextras) ( ) cmake(qt63dinput) ( ) cmake(qt63dlogic) ( ) cmake(qt63dquick) ( ) cmake(qt63dquickanimation) ( ) cmake(qt63dquickextras) ( ) cmake(qt63dquickinput) ( ) cmake(qt63dquickrender) ( ) cmake(qt63dquickscene2d) ( ) cmake(qt63dquickscene3d) ( ) cmake(qt63drender) ( ) cmake(qt6assimpsceneimportplugin) ( ) cmake(qt6defaultgeometryloaderplugin) ( ) cmake(qt6gltfgeometryloaderplugin) ( ) cmake(qt6gltfsceneexportplugin) ( ) cmake(qt6gltfsceneimportplugin) ( ) cmake(qt6openglrendererplugin) ( ) cmake(qt6qtquickscene2dplugin) ( ) cmake(qt6qtquickscene3dplugin) ( ) cmake(qt6quick3danimationplugin) ( ) cmake(qt6quick3dcoreplugin) ( ) cmake(qt6quick3dextrasplugin) ( ) cmake(qt6quick3dinputplugin) ( ) cmake(qt6quick3dlogicplugin) ( ) cmake(qt6quick3drenderplugin) ( ) cmake(qt6rhirendererplugin) ( ) cmake(qt6scene2dplugin) ( ) pkgconfig(Qt63DAnimation) ( =  6.8.1) pkgconfig(Qt63DCore) ( =  6.8.1) pkgconfig(Qt63DExtras) ( =  6.8.1) pkgconfig(Qt63DInput) ( =  6.8.1) pkgconfig(Qt63DLogic) ( =  6.8.1) pkgconfig(Qt63DQuick) ( =  6.8.1) pkgconfig(Qt63DQuickAnimation) ( =  6.8.1) pkgconfig(Qt63DQuickExtras) ( =  6.8.1) pkgconfig(Qt63DQuickInput) ( =  6.8.1) pkgconfig(Qt63DQuickRender) ( =  6.8.1) pkgconfig(Qt63DQuickScene2D) ( =  6.8.1) pkgconfig(Qt63DQuickScene3D) ( =  6.8.1) pkgconfig(Qt63DRender) ( =  6.8.1) qt6-qt3d-devel ( =  6.8.1-1.el10) qt6-qt3d-devel(x86-64) ( =  6.8.1-1.el10)"

URI_qt6-qt3d-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qt3d-examples-6.8.1-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:qt6-qt3d-examples = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.34)(64bit) ( ) libgcc_s.so.1()(64bit) ( ) libgcc_s.so.1(GCC_3.0)(64bit) ( ) libstdc++.so.6()(64bit) ( ) libstdc++.so.6(CXXABI_1.3)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.9)(64bit) ( ) libQt6Core.so.6()(64bit) ( ) libQt6Core.so.6(Qt_6)(64bit) ( ) libQt6Core.so.6(Qt_6.8)(64bit) ( ) libQt6Gui.so.6()(64bit) ( ) libQt6Gui.so.6(Qt_6)(64bit) ( ) libQt6Widgets.so.6()(64bit) ( ) libQt6Widgets.so.6(Qt_6)(64bit) ( ) libQt6Qml.so.6()(64bit) ( ) libQt6Qml.so.6(Qt_6)(64bit) ( ) libQt6Quick.so.6()(64bit) ( ) libQt6Quick.so.6(Qt_6)(64bit) ( ) libQt63DCore.so.6()(64bit) ( ) libQt63DCore.so.6(Qt_6)(64bit) ( ) libQt63DExtras.so.6()(64bit) ( ) libQt63DExtras.so.6(Qt_6)(64bit) ( ) libQt63DQuick.so.6()(64bit) ( ) libQt63DQuick.so.6(Qt_6)(64bit) ( ) libQt63DQuickExtras.so.6()(64bit) ( ) libQt63DQuickExtras.so.6(Qt_6)(64bit) ( ) libQt63DRender.so.6()(64bit) ( ) libQt63DRender.so.6(Qt_6)(64bit) ( ) qt6-qt3d(x86-64) ( =  6.8.1-1.el10)"
RPROVIDES:qt6-qt3d-examples = "qt6-qt3d-examples ( =  6.8.1-1.el10) qt6-qt3d-examples(x86-64) ( =  6.8.1-1.el10)"

URI_qt6-qt3d-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qt3d-tests-6.8.1-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:qt6-qt3d-tests = "rtld(GNU_HASH) ( ) libgcc_s.so.1()(64bit) ( ) libgcc_s.so.1(GCC_3.0)(64bit) ( ) libc.so.6(GLIBC_2.34)(64bit) ( ) libstdc++.so.6()(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4)(64bit) ( ) libstdc++.so.6(CXXABI_1.3)(64bit) ( ) libstdc++.so.6(CXXABI_1.3.9)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.30)(64bit) ( ) libstdc++.so.6(GLIBCXX_3.4.20)(64bit) ( ) libQt6Core.so.6()(64bit) ( ) libQt6Core.so.6(Qt_6)(64bit) ( ) libQt6Core.so.6(Qt_6.8)(64bit) ( ) libQt6Test.so.6()(64bit) ( ) libQt6Test.so.6(Qt_6)(64bit) ( ) libQt6Gui.so.6()(64bit) ( ) libQt6Gui.so.6(Qt_6)(64bit) ( ) libQt6Core.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DAnimation.so.6()(64bit) ( ) libQt63DAnimation.so.6(Qt_6)(64bit) ( ) libQt63DCore.so.6()(64bit) ( ) libQt63DCore.so.6(Qt_6)(64bit) ( ) libQt63DCore.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) libQt63DRender.so.6()(64bit) ( ) libQt63DRender.so.6(Qt_6)(64bit) ( ) libQt63DRender.so.6(Qt_6.8_PRIVATE_API)(64bit) ( ) qt6-qt3d(x86-64) ( =  6.8.1-1.el10)"
RPROVIDES:qt6-qt3d-tests = "qt6-qt3d-tests ( =  6.8.1-1.el10) qt6-qt3d-tests(x86-64) ( =  6.8.1-1.el10)"
