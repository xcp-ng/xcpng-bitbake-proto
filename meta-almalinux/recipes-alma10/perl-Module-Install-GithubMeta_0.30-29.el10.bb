
PN = "perl-Module-Install-GithubMeta"
PE = "0"
PV = "0.30"
PR = "29.el10"
PACKAGES = "perl-Module-Install-GithubMeta"


URI_perl-Module-Install-GithubMeta = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Install-GithubMeta-0.30-29.el10.noarch.rpm;unpack=0"
RDEPENDS:perl-Module-Install-GithubMeta = "perl(strict) ( ) perl(warnings) ( ) perl(vars) ( ) perl-libs ( ) perl(base) ( ) perl(Cwd) ( ) perl(Module::Install::Base) ( ) perl(Module::Install) ( >=  0.85)"
RPROVIDES:perl-Module-Install-GithubMeta = "perl(Module::Install::GithubMeta) ( =  0.30) perl-Module-Install-GithubMeta ( =  0.30-29.el10)"
