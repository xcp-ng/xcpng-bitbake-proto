
PN = "hunspell-si"
PE = "0"
PV = "0.2.1"
PR = "34.el10"
PACKAGES = "hunspell-si"


URI_hunspell-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-si-0.2.1-34.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-si = " \
 hunspell \
"
