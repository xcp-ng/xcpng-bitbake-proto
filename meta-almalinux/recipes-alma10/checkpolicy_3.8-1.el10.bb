
PN = "checkpolicy"
PE = "0"
PV = "3.8"
PR = "1.el10"
PACKAGES = "checkpolicy"


URI_checkpolicy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/checkpolicy-3.8-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:checkpolicy = "
 glibc
"
