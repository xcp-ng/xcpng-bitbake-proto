
PN = "byaccj"
PE = "0"
PV = "1.15"
PR = "36.el10"
PACKAGES = "byaccj"


URI_byaccj = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/byaccj-1.15-36.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:byaccj = "
 glibc
"
