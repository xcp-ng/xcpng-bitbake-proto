
PN = "hunspell-is"
PE = "0"
PV = "0.20090823"
PR = "31.el10"
PACKAGES = "hunspell-is"


URI_hunspell-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-is-0.20090823-31.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-is = "hunspell-filesystem ( )"
RPROVIDES:hunspell-is = "hunspell-is ( =  0.20090823-31.el10)"
