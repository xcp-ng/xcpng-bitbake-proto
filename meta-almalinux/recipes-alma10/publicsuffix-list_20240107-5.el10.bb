
PN = "publicsuffix-list"
PE = "0"
PV = "20240107"
PR = "5.el10"
PACKAGES = "publicsuffix-list-dafsa publicsuffix-list"


URI_publicsuffix-list-dafsa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/publicsuffix-list-dafsa-20240107-5.el10.noarch.rpm;unpack=0"
RDEPENDS:publicsuffix-list-dafsa = ""
RPROVIDES:publicsuffix-list-dafsa = "publicsuffix-list-dafsa ( =  20240107-5.el10)"

URI_publicsuffix-list = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/publicsuffix-list-20240107-5.el10.noarch.rpm;unpack=0"
RDEPENDS:publicsuffix-list = ""
RPROVIDES:publicsuffix-list = "publicsuffix-list ( =  20240107-5.el10)"
