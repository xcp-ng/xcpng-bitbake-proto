
PN = "xhtml1-dtds"
PE = "0"
PV = "1.0"
PR = "20020801.22.el10"
PACKAGES = "xhtml1-dtds"


URI_xhtml1-dtds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xhtml1-dtds-1.0-20020801.22.el10.noarch.rpm;unpack=0"
RDEPENDS:xhtml1-dtds = "/bin/sh ( ) /usr/bin/xmlcatalog ( ) xml-common ( ) sgml-common ( ) libxml2 ( >=  2.4.8)"
RPROVIDES:xhtml1-dtds = "xhtml1-dtds ( =  1.0-20020801.22.el10)"
