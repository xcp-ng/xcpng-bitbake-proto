
PN = "opencl-headers"
PE = "0"
PV = "3.0"
PR = "23.20231212git2368105.el10"
PACKAGES = "opencl-headers"


URI_opencl-headers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/opencl-headers-3.0-23.20231212git2368105.el10.noarch.rpm;unpack=0"
RDEPENDS:opencl-headers = " \
 opencl-headers \
 pkgconf-pkg-config \
"
