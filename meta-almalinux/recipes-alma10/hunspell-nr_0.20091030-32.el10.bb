
PN = "hunspell-nr"
PE = "0"
PV = "0.20091030"
PR = "32.el10"
PACKAGES = "hunspell-nr"


URI_hunspell-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-nr-0.20091030-32.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-nr = "
 hunspell
"
