
PN = "php-pecl-xdebug3"
PE = "0"
PV = "3.3.1"
PR = "6.el10"
PACKAGES = "php-pecl-xdebug3"


URI_php-pecl-xdebug3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pecl-xdebug3-3.3.1-6.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:php-pecl-xdebug3 = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) libm.so.6()(64bit) ( ) libm.so.6(GLIBC_2.29)(64bit) ( ) libz.so.1()(64bit) ( ) libz.so.1(ZLIB_1.2.9)(64bit) ( ) php(api) ( =  20230831-64) php(zend-abi) ( =  20230831-64)"
RPROVIDES:php-pecl-xdebug3 = "config(php-pecl-xdebug3) ( =  3.3.1-6.el10) php-pecl(Xdebug) ( =  3.3.1) php-pecl(Xdebug)(x86-64) ( =  3.3.1) php-pecl-xdebug ( =  3.3.1-6.el10) php-pecl-xdebug(x86-64) ( =  3.3.1-6.el10) php-pecl-xdebug3 ( =  3.3.1-6.el10) php-pecl-xdebug3(x86-64) ( =  3.3.1-6.el10) php-xdebug ( =  3.3.1) php-xdebug(x86-64) ( =  3.3.1)"
