
inherit dnf-bridge

PN = "subscription-manager-rhsm-certificates"
PE = "0"
PV = "20220623"
PR = "6.el10"
PACKAGES = "subscription-manager-rhsm-certificates"


URI_subscription-manager-rhsm-certificates = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/subscription-manager-rhsm-certificates-20220623-6.el10.noarch.rpm;unpack=0"
RDEPENDS:subscription-manager-rhsm-certificates = ""
