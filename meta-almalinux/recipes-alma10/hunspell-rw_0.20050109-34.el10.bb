
PN = "hunspell-rw"
PE = "0"
PV = "0.20050109"
PR = "34.el10"
PACKAGES = "hunspell-rw"


URI_hunspell-rw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-rw-0.20050109-34.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-rw = " \
 hunspell \
"
