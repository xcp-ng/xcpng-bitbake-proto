
PN = "tar"
PE = "2"
PV = "1.35"
PR = "7.el10"
PACKAGES = ""

