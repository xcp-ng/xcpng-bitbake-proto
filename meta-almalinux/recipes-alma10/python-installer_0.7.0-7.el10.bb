
PN = "python-installer"
PE = "0"
PV = "0.7.0"
PR = "7.el10"
PACKAGES = "python3-installer"


URI_python3-installer = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-installer-0.7.0-7.el10.noarch.rpm;unpack=0"
RDEPENDS:python3-installer = " \
 python3 \
"
