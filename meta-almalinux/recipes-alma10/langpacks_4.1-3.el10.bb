
PN = "langpacks"
PE = "0"
PV = "4.1"
PR = "3.el10"
PACKAGES = "default-fonts-core-mono default-fonts-core-sans default-fonts-core-serif default-fonts default-fonts-am default-fonts-ar default-fonts-as default-fonts-ast default-fonts-be default-fonts-bg default-fonts-bn default-fonts-bo default-fonts-br default-fonts-chr default-fonts-cjk default-fonts-cjk-mono default-fonts-cjk-sans default-fonts-cjk-serif default-fonts-core default-fonts-core-emoji default-fonts-core-math default-fonts-dv default-fonts-dz default-fonts-el default-fonts-eo default-fonts-eu default-fonts-fa default-fonts-gu default-fonts-he default-fonts-hi default-fonts-hy default-fonts-ia default-fonts-iu default-fonts-ka default-fonts-km default-fonts-kn default-fonts-ku default-fonts-lo default-fonts-mai default-fonts-ml default-fonts-mni default-fonts-mr default-fonts-my default-fonts-nb default-fonts-ne default-fonts-nn default-fonts-nr default-fonts-nso default-fonts-or default-fonts-other default-fonts-other-mono default-fonts-other-sans default-fonts-other-serif default-fonts-pa default-fonts-ru default-fonts-sat default-fonts-si default-fonts-ss default-fonts-ta default-fonts-te default-fonts-th default-fonts-tn default-fonts-ts default-fonts-uk default-fonts-ur default-fonts-ve default-fonts-vi default-fonts-xh default-fonts-yi default-fonts-zu langpacks-af langpacks-am langpacks-ar langpacks-as langpacks-ast langpacks-be langpacks-bg langpacks-bn langpacks-bo langpacks-br langpacks-bs langpacks-ca langpacks-chr langpacks-core-af langpacks-core-am langpacks-core-ar langpacks-core-as langpacks-core-ast langpacks-core-be langpacks-core-bg langpacks-core-bn langpacks-core-bo langpacks-core-br langpacks-core-bs langpacks-core-ca langpacks-core-chr langpacks-core-cs langpacks-core-cy langpacks-core-da langpacks-core-de langpacks-core-dv langpacks-core-dz langpacks-core-el langpacks-core-en langpacks-core-en_GB langpacks-core-eo langpacks-core-es langpacks-core-et langpacks-core-eu langpacks-core-fa langpacks-core-fi langpacks-core-fr langpacks-core-ga langpacks-core-gl langpacks-core-gu langpacks-core-he langpacks-core-hi langpacks-core-hr langpacks-core-hu langpacks-core-hy langpacks-core-ia langpacks-core-id langpacks-core-is langpacks-core-it langpacks-core-iu langpacks-core-ja langpacks-core-ka langpacks-core-kk langpacks-core-km langpacks-core-kn langpacks-core-ko langpacks-core-ku langpacks-core-lo langpacks-core-lt langpacks-core-lv langpacks-core-mai langpacks-core-mk langpacks-core-ml langpacks-core-mni langpacks-core-mr langpacks-core-ms langpacks-core-my langpacks-core-nb langpacks-core-ne langpacks-core-nl langpacks-core-nn langpacks-core-nr langpacks-core-nso langpacks-core-or langpacks-core-pa langpacks-core-pl langpacks-core-pt langpacks-core-pt_BR langpacks-core-ro langpacks-core-ru langpacks-core-sat langpacks-core-si langpacks-core-sk langpacks-core-sl langpacks-core-sq langpacks-core-sr langpacks-core-ss langpacks-core-sv langpacks-core-ta langpacks-core-te langpacks-core-th langpacks-core-tn langpacks-core-tr langpacks-core-ts langpacks-core-uk langpacks-core-ur langpacks-core-ve langpacks-core-vi langpacks-core-xh langpacks-core-yi langpacks-core-zh_CN langpacks-core-zh_HK langpacks-core-zh_TW langpacks-core-zu langpacks-cs langpacks-cy langpacks-da langpacks-de langpacks-dv langpacks-dz langpacks-el langpacks-en langpacks-en_GB langpacks-eo langpacks-es langpacks-et langpacks-eu langpacks-fa langpacks-fi langpacks-fonts-af langpacks-fonts-am langpacks-fonts-ar langpacks-fonts-as langpacks-fonts-ast langpacks-fonts-be langpacks-fonts-bg langpacks-fonts-bn langpacks-fonts-bo langpacks-fonts-br langpacks-fonts-bs langpacks-fonts-ca langpacks-fonts-chr langpacks-fonts-cs langpacks-fonts-cy langpacks-fonts-da langpacks-fonts-de langpacks-fonts-dv langpacks-fonts-dz langpacks-fonts-el langpacks-fonts-en langpacks-fonts-eo langpacks-fonts-es langpacks-fonts-et langpacks-fonts-eu langpacks-fonts-fa langpacks-fonts-fi langpacks-fonts-fr langpacks-fonts-ga langpacks-fonts-gl langpacks-fonts-gu langpacks-fonts-he langpacks-fonts-hi langpacks-fonts-hr langpacks-fonts-hu langpacks-fonts-hy langpacks-fonts-ia langpacks-fonts-id langpacks-fonts-is langpacks-fonts-it langpacks-fonts-iu langpacks-fonts-ja langpacks-fonts-ka langpacks-fonts-kk langpacks-fonts-km langpacks-fonts-kn langpacks-fonts-ko langpacks-fonts-ku langpacks-fonts-lo langpacks-fonts-lt langpacks-fonts-lv langpacks-fonts-mai langpacks-fonts-mk langpacks-fonts-ml langpacks-fonts-mni langpacks-fonts-mr langpacks-fonts-ms langpacks-fonts-my langpacks-fonts-nb langpacks-fonts-ne langpacks-fonts-nl langpacks-fonts-nn langpacks-fonts-nr langpacks-fonts-nso langpacks-fonts-or langpacks-fonts-pa langpacks-fonts-pl langpacks-fonts-pt langpacks-fonts-ro langpacks-fonts-ru langpacks-fonts-sat langpacks-fonts-si langpacks-fonts-sk langpacks-fonts-sl langpacks-fonts-sq langpacks-fonts-sr langpacks-fonts-ss langpacks-fonts-sv langpacks-fonts-ta langpacks-fonts-te langpacks-fonts-th langpacks-fonts-tn langpacks-fonts-tr langpacks-fonts-ts langpacks-fonts-uk langpacks-fonts-ur langpacks-fonts-ve langpacks-fonts-vi langpacks-fonts-xh langpacks-fonts-yi langpacks-fonts-zh_CN langpacks-fonts-zh_HK langpacks-fonts-zh_TW langpacks-fonts-zu langpacks-fr langpacks-ga langpacks-gl langpacks-gu langpacks-he langpacks-hi langpacks-hr langpacks-hu langpacks-hy langpacks-ia langpacks-id langpacks-is langpacks-it langpacks-iu langpacks-ja langpacks-ka langpacks-kk langpacks-km langpacks-kn langpacks-ko langpacks-ku langpacks-lo langpacks-lt langpacks-lv langpacks-mai langpacks-mk langpacks-ml langpacks-mni langpacks-mr langpacks-ms langpacks-my langpacks-nb langpacks-ne langpacks-nl langpacks-nn langpacks-nr langpacks-nso langpacks-or langpacks-pa langpacks-pl langpacks-pt langpacks-pt_BR langpacks-ro langpacks-ru langpacks-sat langpacks-si langpacks-sk langpacks-sl langpacks-sq langpacks-sr langpacks-ss langpacks-sv langpacks-ta langpacks-te langpacks-th langpacks-tn langpacks-tr langpacks-ts langpacks-uk langpacks-ur langpacks-ve langpacks-vi langpacks-xh langpacks-yi langpacks-zh_CN langpacks-zh_HK langpacks-zh_TW langpacks-zu"


URI_default-fonts-core-mono = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/default-fonts-core-mono-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-core-mono = "google-noto-sans-mono-vf-fonts ( ) redhat-mono-vf-fonts ( )"
RPROVIDES:default-fonts-core-mono = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-core-mono.metainfo.xml) ( ) default-fonts-core-mono ( =  4.1-3.el10)"

URI_default-fonts-core-sans = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/default-fonts-core-sans-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-core-sans = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-core-sans = "metainfo() ( ) font(:lang=af) ( ) font(:lang=bs) ( ) font(:lang=ca) ( ) font(:lang=cs) ( ) font(:lang=cy) ( ) font(:lang=da) ( ) font(:lang=de) ( ) font(:lang=en) ( ) font(:lang=es) ( ) font(:lang=et) ( ) font(:lang=fi) ( ) font(:lang=fr) ( ) font(:lang=ga) ( ) font(:lang=gl) ( ) font(:lang=hr) ( ) font(:lang=hu) ( ) font(:lang=id) ( ) font(:lang=is) ( ) font(:lang=it) ( ) font(:lang=kk) ( ) font(:lang=lt) ( ) font(:lang=lv) ( ) font(:lang=mk) ( ) font(:lang=ms) ( ) font(:lang=nl) ( ) font(:lang=pl) ( ) font(:lang=pt) ( ) font(:lang=ro) ( ) font(:lang=sk) ( ) font(:lang=sl) ( ) font(:lang=sq) ( ) font(:lang=sr) ( ) font(:lang=sv) ( ) font(:lang=tr) ( ) metainfo(org.fedoraproject.default-fonts-af.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-bs.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-ca.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-core-sans.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-cs.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-cy.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-da.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-de.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-en.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-es.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-et.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-fi.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-fr.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-ga.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-gl.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-hr.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-hu.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-id.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-is.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-it.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-kk.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-lt.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-lv.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-mk.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-ms.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-nl.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-pl.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-pt.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-ro.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-sk.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-sl.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-sq.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-sr.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-sv.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-tr.metainfo.xml) ( ) default-fonts-af ( =  4.1-3.el10) default-fonts-bs ( =  4.1-3.el10) default-fonts-ca ( =  4.1-3.el10) default-fonts-core-sans ( =  4.1-3.el10) default-fonts-cs ( =  4.1-3.el10) default-fonts-cy ( =  4.1-3.el10) default-fonts-da ( =  4.1-3.el10) default-fonts-de ( =  4.1-3.el10) default-fonts-en ( =  4.1-3.el10) default-fonts-es ( =  4.1-3.el10) default-fonts-et ( =  4.1-3.el10) default-fonts-fi ( =  4.1-3.el10) default-fonts-fr ( =  4.1-3.el10) default-fonts-ga ( =  4.1-3.el10) default-fonts-gl ( =  4.1-3.el10) default-fonts-hr ( =  4.1-3.el10) default-fonts-hu ( =  4.1-3.el10) default-fonts-id ( =  4.1-3.el10) default-fonts-is ( =  4.1-3.el10) default-fonts-it ( =  4.1-3.el10) default-fonts-kk ( =  4.1-3.el10) default-fonts-lt ( =  4.1-3.el10) default-fonts-lv ( =  4.1-3.el10) default-fonts-mk ( =  4.1-3.el10) default-fonts-ms ( =  4.1-3.el10) default-fonts-nl ( =  4.1-3.el10) default-fonts-pl ( =  4.1-3.el10) default-fonts-pt ( =  4.1-3.el10) default-fonts-ro ( =  4.1-3.el10) default-fonts-sk ( =  4.1-3.el10) default-fonts-sl ( =  4.1-3.el10) default-fonts-sq ( =  4.1-3.el10) default-fonts-sr ( =  4.1-3.el10) default-fonts-sv ( =  4.1-3.el10) default-fonts-tr ( =  4.1-3.el10) langpacks-core-font-af ( =  4.1-3.el10) langpacks-core-font-bs ( =  4.1-3.el10) langpacks-core-font-ca ( =  4.1-3.el10) langpacks-core-font-cs ( =  4.1-3.el10) langpacks-core-font-cy ( =  4.1-3.el10) langpacks-core-font-da ( =  4.1-3.el10) langpacks-core-font-de ( =  4.1-3.el10) langpacks-core-font-en ( =  4.1-3.el10) langpacks-core-font-es ( =  4.1-3.el10) langpacks-core-font-et ( =  4.1-3.el10) langpacks-core-font-fi ( =  4.1-3.el10) langpacks-core-font-fr ( =  4.1-3.el10) langpacks-core-font-ga ( =  4.1-3.el10) langpacks-core-font-gl ( =  4.1-3.el10) langpacks-core-font-hr ( =  4.1-3.el10) langpacks-core-font-hu ( =  4.1-3.el10) langpacks-core-font-id ( =  4.1-3.el10) langpacks-core-font-is ( =  4.1-3.el10) langpacks-core-font-it ( =  4.1-3.el10) langpacks-core-font-kk ( =  4.1-3.el10) langpacks-core-font-lt ( =  4.1-3.el10) langpacks-core-font-lv ( =  4.1-3.el10) langpacks-core-font-mk ( =  4.1-3.el10) langpacks-core-font-ms ( =  4.1-3.el10) langpacks-core-font-nl ( =  4.1-3.el10) langpacks-core-font-pl ( =  4.1-3.el10) langpacks-core-font-pt ( =  4.1-3.el10) langpacks-core-font-ro ( =  4.1-3.el10) langpacks-core-font-sk ( =  4.1-3.el10) langpacks-core-font-sl ( =  4.1-3.el10) langpacks-core-font-sq ( =  4.1-3.el10) langpacks-core-font-sr ( =  4.1-3.el10) langpacks-core-font-sv ( =  4.1-3.el10) langpacks-core-font-tr ( =  4.1-3.el10)"

URI_default-fonts-core-serif = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/default-fonts-core-serif-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-core-serif = "google-noto-serif-vf-fonts ( )"
RPROVIDES:default-fonts-core-serif = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-core-serif.metainfo.xml) ( ) default-fonts-core-serif ( =  4.1-3.el10)"

URI_default-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts = "default-fonts-cjk ( =  4.1-3.el10) default-fonts-core ( =  4.1-3.el10) default-fonts-other ( =  4.1-3.el10)"
RPROVIDES:default-fonts = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts.metainfo.xml) ( ) default-fonts ( =  4.1-3.el10)"

URI_default-fonts-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-am-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-am = "google-noto-sans-ethiopic-vf-fonts ( )"
RPROVIDES:default-fonts-am = "metainfo() ( ) font(:lang=am) ( ) metainfo(org.fedoraproject.default-fonts-am.metainfo.xml) ( ) default-fonts-am ( =  4.1-3.el10) langpacks-core-font-am ( =  4.1-3.el10)"

URI_default-fonts-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ar-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ar = "google-noto-sans-arabic-vf-fonts ( )"
RPROVIDES:default-fonts-ar = "metainfo() ( ) font(:lang=ar) ( ) metainfo(org.fedoraproject.default-fonts-ar.metainfo.xml) ( ) default-fonts-ar ( =  4.1-3.el10) langpacks-core-font-ar ( =  4.1-3.el10)"

URI_default-fonts-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-as-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-as = "google-noto-sans-bengali-vf-fonts ( )"
RPROVIDES:default-fonts-as = "metainfo() ( ) font(:lang=as) ( ) metainfo(org.fedoraproject.default-fonts-as.metainfo.xml) ( ) default-fonts-as ( =  4.1-3.el10) langpacks-core-font-as ( =  4.1-3.el10)"

URI_default-fonts-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ast-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ast = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-ast = "metainfo() ( ) font(:lang=ast) ( ) metainfo(org.fedoraproject.default-fonts-ast.metainfo.xml) ( ) default-fonts-ast ( =  4.1-3.el10) langpacks-core-font-ast ( =  4.1-3.el10)"

URI_default-fonts-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-be-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-be = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-be = "metainfo() ( ) font(:lang=be) ( ) metainfo(org.fedoraproject.default-fonts-be.metainfo.xml) ( ) default-fonts-be ( =  4.1-3.el10) langpacks-core-font-be ( =  4.1-3.el10)"

URI_default-fonts-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-bg-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-bg = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-bg = "metainfo() ( ) font(:lang=bg) ( ) metainfo(org.fedoraproject.default-fonts-bg.metainfo.xml) ( ) default-fonts-bg ( =  4.1-3.el10) langpacks-core-font-bg ( =  4.1-3.el10)"

URI_default-fonts-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-bn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-bn = "google-noto-sans-bengali-vf-fonts ( )"
RPROVIDES:default-fonts-bn = "metainfo() ( ) font(:lang=bn) ( ) metainfo(org.fedoraproject.default-fonts-bn.metainfo.xml) ( ) default-fonts-bn ( =  4.1-3.el10) langpacks-core-font-bn ( =  4.1-3.el10)"

URI_default-fonts-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-bo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-bo = "jomolhari-fonts ( )"
RPROVIDES:default-fonts-bo = "metainfo() ( ) font(:lang=bo) ( ) metainfo(org.fedoraproject.default-fonts-bo.metainfo.xml) ( ) default-fonts-bo ( =  4.1-3.el10) langpacks-core-font-bo ( =  4.1-3.el10)"

URI_default-fonts-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-br-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-br = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-br = "metainfo() ( ) font(:lang=br) ( ) metainfo(org.fedoraproject.default-fonts-br.metainfo.xml) ( ) default-fonts-br ( =  4.1-3.el10) langpacks-core-font-br ( =  4.1-3.el10)"

URI_default-fonts-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-chr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-chr = "google-noto-sans-cherokee-vf-fonts ( )"
RPROVIDES:default-fonts-chr = "metainfo() ( ) font(:lang=chr) ( ) metainfo(org.fedoraproject.default-fonts-chr.metainfo.xml) ( ) default-fonts-chr ( =  4.1-3.el10) langpacks-core-font-chr ( =  4.1-3.el10)"

URI_default-fonts-cjk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-cjk = "default-fonts-cjk-mono ( =  4.1-3.el10) default-fonts-cjk-sans ( =  4.1-3.el10) default-fonts-cjk-serif ( =  4.1-3.el10)"
RPROVIDES:default-fonts-cjk = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-cjk.metainfo.xml) ( ) default-fonts-cjk ( =  4.1-3.el10)"

URI_default-fonts-cjk-mono = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-mono-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-cjk-mono = "google-noto-sans-mono-cjk-vf-fonts ( )"
RPROVIDES:default-fonts-cjk-mono = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-cjk-mono.metainfo.xml) ( ) default-fonts-cjk-mono ( =  4.1-3.el10)"

URI_default-fonts-cjk-sans = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-sans-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-cjk-sans = "google-noto-sans-cjk-vf-fonts ( )"
RPROVIDES:default-fonts-cjk-sans = "metainfo() ( ) font(:lang=ja) ( ) font(:lang=ko) ( ) font(:lang=zh_CN) ( ) font(:lang=zh_HK) ( ) font(:lang=zh_TW) ( ) metainfo(org.fedoraproject.default-fonts-cjk-sans.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-ja.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-ko.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-zh_CN.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-zh_HK.metainfo.xml) ( ) metainfo(org.fedoraproject.default-fonts-zh_TW.metainfo.xml) ( ) default-fonts-cjk-sans ( =  4.1-3.el10) default-fonts-ja ( =  4.1-3.el10) default-fonts-ko ( =  4.1-3.el10) default-fonts-zh_CN ( =  4.1-3.el10) default-fonts-zh_HK ( =  4.1-3.el10) default-fonts-zh_TW ( =  4.1-3.el10) langpacks-core-font-ja ( =  4.1-3.el10) langpacks-core-font-ko ( =  4.1-3.el10) langpacks-core-font-zh_CN ( =  4.1-3.el10) langpacks-core-font-zh_HK ( =  4.1-3.el10) langpacks-core-font-zh_TW ( =  4.1-3.el10)"

URI_default-fonts-cjk-serif = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-serif-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-cjk-serif = "google-noto-serif-cjk-vf-fonts ( )"
RPROVIDES:default-fonts-cjk-serif = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-cjk-serif.metainfo.xml) ( ) default-fonts-cjk-serif ( =  4.1-3.el10)"

URI_default-fonts-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-core-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-core = "default-fonts-core-emoji ( =  4.1-3.el10) default-fonts-core-math ( =  4.1-3.el10) default-fonts-core-mono ( =  4.1-3.el10) default-fonts-core-sans ( =  4.1-3.el10) default-fonts-core-serif ( =  4.1-3.el10)"
RPROVIDES:default-fonts-core = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-core.metainfo.xml) ( ) default-fonts-core ( =  4.1-3.el10)"

URI_default-fonts-core-emoji = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-core-emoji-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-core-emoji = "google-noto-emoji-color-fonts ( )"
RPROVIDES:default-fonts-core-emoji = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-core-emoji.metainfo.xml) ( ) default-fonts-core-emoji ( =  4.1-3.el10)"

URI_default-fonts-core-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-core-math-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-core-math = "google-noto-sans-math-fonts ( ) google-noto-sans-symbols-2-fonts ( ) google-noto-sans-symbols-vf-fonts ( ) stix-fonts ( )"
RPROVIDES:default-fonts-core-math = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-core-math.metainfo.xml) ( ) default-fonts-core-math ( =  4.1-3.el10)"

URI_default-fonts-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-dv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-dv = "google-noto-sans-thaana-vf-fonts ( )"
RPROVIDES:default-fonts-dv = "metainfo() ( ) font(:lang=dv) ( ) metainfo(org.fedoraproject.default-fonts-dv.metainfo.xml) ( ) default-fonts-dv ( =  4.1-3.el10) langpacks-core-font-dv ( =  4.1-3.el10)"

URI_default-fonts-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-dz-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-dz = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-dz = "metainfo() ( ) font(:lang=dz) ( ) metainfo(org.fedoraproject.default-fonts-dz.metainfo.xml) ( ) default-fonts-dz ( =  4.1-3.el10) langpacks-core-font-dz ( =  4.1-3.el10)"

URI_default-fonts-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-el-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-el = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-el = "metainfo() ( ) font(:lang=el) ( ) metainfo(org.fedoraproject.default-fonts-el.metainfo.xml) ( ) default-fonts-el ( =  4.1-3.el10) langpacks-core-font-el ( =  4.1-3.el10)"

URI_default-fonts-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-eo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-eo = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-eo = "metainfo() ( ) font(:lang=eo) ( ) metainfo(org.fedoraproject.default-fonts-eo.metainfo.xml) ( ) default-fonts-eo ( =  4.1-3.el10) langpacks-core-font-eo ( =  4.1-3.el10)"

URI_default-fonts-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-eu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-eu = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-eu = "metainfo() ( ) font(:lang=eu) ( ) metainfo(org.fedoraproject.default-fonts-eu.metainfo.xml) ( ) default-fonts-eu ( =  4.1-3.el10) langpacks-core-font-eu ( =  4.1-3.el10)"

URI_default-fonts-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-fa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-fa = "vazirmatn-vf-fonts ( )"
RPROVIDES:default-fonts-fa = "metainfo() ( ) font(:lang=fa) ( ) metainfo(org.fedoraproject.default-fonts-fa.metainfo.xml) ( ) default-fonts-fa ( =  4.1-3.el10) langpacks-core-font-fa ( =  4.1-3.el10)"

URI_default-fonts-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-gu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-gu = "google-noto-sans-gujarati-vf-fonts ( )"
RPROVIDES:default-fonts-gu = "metainfo() ( ) font(:lang=gu) ( ) metainfo(org.fedoraproject.default-fonts-gu.metainfo.xml) ( ) default-fonts-gu ( =  4.1-3.el10) langpacks-core-font-gu ( =  4.1-3.el10)"

URI_default-fonts-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-he-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-he = "google-noto-sans-hebrew-vf-fonts ( )"
RPROVIDES:default-fonts-he = "metainfo() ( ) font(:lang=he) ( ) metainfo(org.fedoraproject.default-fonts-he.metainfo.xml) ( ) default-fonts-he ( =  4.1-3.el10) langpacks-core-font-he ( =  4.1-3.el10)"

URI_default-fonts-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-hi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-hi = "google-noto-sans-devanagari-vf-fonts ( )"
RPROVIDES:default-fonts-hi = "metainfo() ( ) font(:lang=hi) ( ) metainfo(org.fedoraproject.default-fonts-hi.metainfo.xml) ( ) default-fonts-hi ( =  4.1-3.el10) langpacks-core-font-hi ( =  4.1-3.el10)"

URI_default-fonts-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-hy-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-hy = "google-noto-sans-armenian-vf-fonts ( )"
RPROVIDES:default-fonts-hy = "metainfo() ( ) font(:lang=hy) ( ) metainfo(org.fedoraproject.default-fonts-hy.metainfo.xml) ( ) default-fonts-hy ( =  4.1-3.el10) langpacks-core-font-hy ( =  4.1-3.el10)"

URI_default-fonts-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ia-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ia = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-ia = "metainfo() ( ) font(:lang=ia) ( ) metainfo(org.fedoraproject.default-fonts-ia.metainfo.xml) ( ) default-fonts-ia ( =  4.1-3.el10) langpacks-core-font-ia ( =  4.1-3.el10)"

URI_default-fonts-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-iu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-iu = "google-noto-sans-canadian-aboriginal-vf-fonts ( )"
RPROVIDES:default-fonts-iu = "metainfo() ( ) font(:lang=iu) ( ) metainfo(org.fedoraproject.default-fonts-iu.metainfo.xml) ( ) default-fonts-iu ( =  4.1-3.el10) langpacks-core-font-iu ( =  4.1-3.el10)"

URI_default-fonts-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ka-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ka = "google-noto-sans-georgian-vf-fonts ( )"
RPROVIDES:default-fonts-ka = "metainfo() ( ) font(:lang=ka) ( ) metainfo(org.fedoraproject.default-fonts-ka.metainfo.xml) ( ) default-fonts-ka ( =  4.1-3.el10) langpacks-core-font-ka ( =  4.1-3.el10)"

URI_default-fonts-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-km-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-km = "google-noto-sans-khmer-vf-fonts ( )"
RPROVIDES:default-fonts-km = "metainfo() ( ) font(:lang=km) ( ) metainfo(org.fedoraproject.default-fonts-km.metainfo.xml) ( ) default-fonts-km ( =  4.1-3.el10) langpacks-core-font-km ( =  4.1-3.el10)"

URI_default-fonts-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-kn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-kn = "google-noto-sans-kannada-vf-fonts ( )"
RPROVIDES:default-fonts-kn = "metainfo() ( ) font(:lang=kn) ( ) metainfo(org.fedoraproject.default-fonts-kn.metainfo.xml) ( ) default-fonts-kn ( =  4.1-3.el10) langpacks-core-font-kn ( =  4.1-3.el10)"

URI_default-fonts-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ku-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ku = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-ku = "metainfo() ( ) font(:lang=ku) ( ) metainfo(org.fedoraproject.default-fonts-ku.metainfo.xml) ( ) default-fonts-ku ( =  4.1-3.el10) langpacks-core-font-ku ( =  4.1-3.el10)"

URI_default-fonts-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-lo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-lo = "google-noto-sans-lao-vf-fonts ( )"
RPROVIDES:default-fonts-lo = "metainfo() ( ) font(:lang=lo) ( ) metainfo(org.fedoraproject.default-fonts-lo.metainfo.xml) ( ) default-fonts-lo ( =  4.1-3.el10) langpacks-core-font-lo ( =  4.1-3.el10)"

URI_default-fonts-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-mai-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-mai = "google-noto-sans-devanagari-vf-fonts ( )"
RPROVIDES:default-fonts-mai = "metainfo() ( ) font(:lang=mai) ( ) metainfo(org.fedoraproject.default-fonts-mai.metainfo.xml) ( ) default-fonts-mai ( =  4.1-3.el10) langpacks-core-font-mai ( =  4.1-3.el10)"

URI_default-fonts-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ml-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ml = "rit-meera-new-fonts ( )"
RPROVIDES:default-fonts-ml = "metainfo() ( ) font(:lang=ml) ( ) metainfo(org.fedoraproject.default-fonts-ml.metainfo.xml) ( ) default-fonts-ml ( =  4.1-3.el10) langpacks-core-font-ml ( =  4.1-3.el10)"

URI_default-fonts-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-mni-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-mni = "google-noto-sans-meetei-mayek-vf-fonts ( )"
RPROVIDES:default-fonts-mni = "metainfo() ( ) font(:lang=mni) ( ) metainfo(org.fedoraproject.default-fonts-mni.metainfo.xml) ( ) default-fonts-mni ( =  4.1-3.el10) langpacks-core-font-mni ( =  4.1-3.el10)"

URI_default-fonts-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-mr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-mr = "google-noto-sans-devanagari-vf-fonts ( )"
RPROVIDES:default-fonts-mr = "metainfo() ( ) font(:lang=mr) ( ) metainfo(org.fedoraproject.default-fonts-mr.metainfo.xml) ( ) default-fonts-mr ( =  4.1-3.el10) langpacks-core-font-mr ( =  4.1-3.el10)"

URI_default-fonts-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-my-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-my = "sil-padauk-fonts ( )"
RPROVIDES:default-fonts-my = "metainfo() ( ) font(:lang=my) ( ) metainfo(org.fedoraproject.default-fonts-my.metainfo.xml) ( ) default-fonts-my ( =  4.1-3.el10) langpacks-core-font-my ( =  4.1-3.el10)"

URI_default-fonts-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nb-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-nb = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-nb = "metainfo() ( ) font(:lang=nb) ( ) metainfo(org.fedoraproject.default-fonts-nb.metainfo.xml) ( ) default-fonts-nb ( =  4.1-3.el10) langpacks-core-font-nb ( =  4.1-3.el10)"

URI_default-fonts-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ne-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ne = "madan-fonts ( )"
RPROVIDES:default-fonts-ne = "metainfo() ( ) font(:lang=ne) ( ) metainfo(org.fedoraproject.default-fonts-ne.metainfo.xml) ( ) default-fonts-ne ( =  4.1-3.el10) langpacks-core-font-ne ( =  4.1-3.el10)"

URI_default-fonts-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-nn = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-nn = "metainfo() ( ) font(:lang=nn) ( ) metainfo(org.fedoraproject.default-fonts-nn.metainfo.xml) ( ) default-fonts-nn ( =  4.1-3.el10) langpacks-core-font-nn ( =  4.1-3.el10)"

URI_default-fonts-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-nr = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-nr = "metainfo() ( ) font(:lang=nr) ( ) metainfo(org.fedoraproject.default-fonts-nr.metainfo.xml) ( ) default-fonts-nr ( =  4.1-3.el10) langpacks-core-font-nr ( =  4.1-3.el10)"

URI_default-fonts-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nso-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-nso = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-nso = "metainfo() ( ) font(:lang=nso) ( ) metainfo(org.fedoraproject.default-fonts-nso.metainfo.xml) ( ) default-fonts-nso ( =  4.1-3.el10) langpacks-core-font-nso ( =  4.1-3.el10)"

URI_default-fonts-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-or-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-or = "google-noto-sans-oriya-vf-fonts ( )"
RPROVIDES:default-fonts-or = "metainfo() ( ) font(:lang=or) ( ) metainfo(org.fedoraproject.default-fonts-or.metainfo.xml) ( ) default-fonts-or ( =  4.1-3.el10) langpacks-core-font-or ( =  4.1-3.el10)"

URI_default-fonts-other = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-other = "default-fonts-other-mono ( =  4.1-3.el10) default-fonts-other-sans ( =  4.1-3.el10) default-fonts-other-serif ( =  4.1-3.el10)"
RPROVIDES:default-fonts-other = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-other.metainfo.xml) ( ) default-fonts-other ( =  4.1-3.el10)"

URI_default-fonts-other-mono = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-mono-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-other-mono = "google-noto-sans-mono-vf-fonts ( ) redhat-mono-vf-fonts ( )"
RPROVIDES:default-fonts-other-mono = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-other-mono.metainfo.xml) ( ) default-fonts-other-mono ( =  4.1-3.el10)"

URI_default-fonts-other-sans = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-sans-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-other-sans = "default-fonts-am ( =  4.1-3.el10) default-fonts-ar ( =  4.1-3.el10) default-fonts-as ( =  4.1-3.el10) default-fonts-ast ( =  4.1-3.el10) default-fonts-be ( =  4.1-3.el10) default-fonts-bg ( =  4.1-3.el10) default-fonts-bn ( =  4.1-3.el10) default-fonts-bo ( =  4.1-3.el10) default-fonts-br ( =  4.1-3.el10) default-fonts-chr ( =  4.1-3.el10) default-fonts-dv ( =  4.1-3.el10) default-fonts-dz ( =  4.1-3.el10) default-fonts-el ( =  4.1-3.el10) default-fonts-eo ( =  4.1-3.el10) default-fonts-eu ( =  4.1-3.el10) default-fonts-fa ( =  4.1-3.el10) default-fonts-gu ( =  4.1-3.el10) default-fonts-he ( =  4.1-3.el10) default-fonts-hi ( =  4.1-3.el10) default-fonts-hy ( =  4.1-3.el10) default-fonts-ia ( =  4.1-3.el10) default-fonts-iu ( =  4.1-3.el10) default-fonts-ka ( =  4.1-3.el10) default-fonts-km ( =  4.1-3.el10) default-fonts-kn ( =  4.1-3.el10) default-fonts-ku ( =  4.1-3.el10) default-fonts-lo ( =  4.1-3.el10) default-fonts-mai ( =  4.1-3.el10) default-fonts-ml ( =  4.1-3.el10) default-fonts-mni ( =  4.1-3.el10) default-fonts-mr ( =  4.1-3.el10) default-fonts-my ( =  4.1-3.el10) default-fonts-nb ( =  4.1-3.el10) default-fonts-ne ( =  4.1-3.el10) default-fonts-nn ( =  4.1-3.el10) default-fonts-nr ( =  4.1-3.el10) default-fonts-nso ( =  4.1-3.el10) default-fonts-or ( =  4.1-3.el10) default-fonts-pa ( =  4.1-3.el10) default-fonts-ru ( =  4.1-3.el10) default-fonts-sat ( =  4.1-3.el10) default-fonts-si ( =  4.1-3.el10) default-fonts-ss ( =  4.1-3.el10) default-fonts-ta ( =  4.1-3.el10) default-fonts-te ( =  4.1-3.el10) default-fonts-th ( =  4.1-3.el10) default-fonts-tn ( =  4.1-3.el10) default-fonts-ts ( =  4.1-3.el10) default-fonts-uk ( =  4.1-3.el10) default-fonts-ur ( =  4.1-3.el10) default-fonts-ve ( =  4.1-3.el10) default-fonts-vi ( =  4.1-3.el10) default-fonts-xh ( =  4.1-3.el10) default-fonts-yi ( =  4.1-3.el10) default-fonts-zu ( =  4.1-3.el10)"
RPROVIDES:default-fonts-other-sans = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-other-sans.metainfo.xml) ( ) default-fonts-other-sans ( =  4.1-3.el10)"

URI_default-fonts-other-serif = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-serif-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-other-serif = "google-noto-serif-vf-fonts ( ) google-noto-naskh-arabic-vf-fonts ( ) google-noto-serif-devanagari-vf-fonts ( ) google-noto-serif-bengali-vf-fonts ( ) google-noto-serif-hebrew-vf-fonts ( ) google-noto-serif-armenian-vf-fonts ( ) google-noto-serif-ethiopic-vf-fonts ( ) google-noto-serif-georgian-vf-fonts ( ) google-noto-serif-gujarati-vf-fonts ( ) google-noto-serif-gurmukhi-vf-fonts ( ) google-noto-serif-kannada-vf-fonts ( ) google-noto-serif-khmer-vf-fonts ( ) google-noto-serif-lao-vf-fonts ( ) google-noto-serif-oriya-vf-fonts ( ) google-noto-serif-sinhala-vf-fonts ( ) google-noto-serif-tamil-vf-fonts ( ) google-noto-serif-telugu-vf-fonts ( ) google-noto-serif-thai-vf-fonts ( ) rit-rachana-fonts ( )"
RPROVIDES:default-fonts-other-serif = "metainfo() ( ) metainfo(org.fedoraproject.default-fonts-other-serif.metainfo.xml) ( ) default-fonts-other-serif ( =  4.1-3.el10)"

URI_default-fonts-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-pa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-pa = "google-noto-sans-gurmukhi-vf-fonts ( )"
RPROVIDES:default-fonts-pa = "metainfo() ( ) font(:lang=pa) ( ) metainfo(org.fedoraproject.default-fonts-pa.metainfo.xml) ( ) default-fonts-pa ( =  4.1-3.el10) langpacks-core-font-pa ( =  4.1-3.el10)"

URI_default-fonts-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ru-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ru = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-ru = "metainfo() ( ) font(:lang=ru) ( ) metainfo(org.fedoraproject.default-fonts-ru.metainfo.xml) ( ) default-fonts-ru ( =  4.1-3.el10) langpacks-core-font-ru ( =  4.1-3.el10)"

URI_default-fonts-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-sat-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-sat = "google-noto-sans-ol-chiki-vf-fonts ( )"
RPROVIDES:default-fonts-sat = "metainfo() ( ) font(:lang=sat) ( ) metainfo(org.fedoraproject.default-fonts-sat.metainfo.xml) ( ) default-fonts-sat ( =  4.1-3.el10) langpacks-core-font-sat ( =  4.1-3.el10)"

URI_default-fonts-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-si-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-si = "google-noto-sans-sinhala-vf-fonts ( )"
RPROVIDES:default-fonts-si = "metainfo() ( ) font(:lang=si) ( ) metainfo(org.fedoraproject.default-fonts-si.metainfo.xml) ( ) default-fonts-si ( =  4.1-3.el10) langpacks-core-font-si ( =  4.1-3.el10)"

URI_default-fonts-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ss-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ss = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-ss = "metainfo() ( ) font(:lang=ss) ( ) metainfo(org.fedoraproject.default-fonts-ss.metainfo.xml) ( ) default-fonts-ss ( =  4.1-3.el10) langpacks-core-font-ss ( =  4.1-3.el10)"

URI_default-fonts-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ta-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ta = "google-noto-sans-tamil-vf-fonts ( )"
RPROVIDES:default-fonts-ta = "metainfo() ( ) font(:lang=ta) ( ) metainfo(org.fedoraproject.default-fonts-ta.metainfo.xml) ( ) default-fonts-ta ( =  4.1-3.el10) langpacks-core-font-ta ( =  4.1-3.el10)"

URI_default-fonts-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-te-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-te = "google-noto-sans-telugu-vf-fonts ( )"
RPROVIDES:default-fonts-te = "metainfo() ( ) font(:lang=te) ( ) metainfo(org.fedoraproject.default-fonts-te.metainfo.xml) ( ) default-fonts-te ( =  4.1-3.el10) langpacks-core-font-te ( =  4.1-3.el10)"

URI_default-fonts-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-th-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-th = "google-noto-sans-thai-vf-fonts ( )"
RPROVIDES:default-fonts-th = "metainfo() ( ) font(:lang=th) ( ) metainfo(org.fedoraproject.default-fonts-th.metainfo.xml) ( ) default-fonts-th ( =  4.1-3.el10) langpacks-core-font-th ( =  4.1-3.el10)"

URI_default-fonts-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-tn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-tn = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-tn = "metainfo() ( ) font(:lang=tn) ( ) metainfo(org.fedoraproject.default-fonts-tn.metainfo.xml) ( ) default-fonts-tn ( =  4.1-3.el10) langpacks-core-font-tn ( =  4.1-3.el10)"

URI_default-fonts-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ts-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ts = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-ts = "metainfo() ( ) font(:lang=ts) ( ) metainfo(org.fedoraproject.default-fonts-ts.metainfo.xml) ( ) default-fonts-ts ( =  4.1-3.el10) langpacks-core-font-ts ( =  4.1-3.el10)"

URI_default-fonts-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-uk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-uk = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-uk = "metainfo() ( ) font(:lang=uk) ( ) metainfo(org.fedoraproject.default-fonts-uk.metainfo.xml) ( ) default-fonts-uk ( =  4.1-3.el10) langpacks-core-font-uk ( =  4.1-3.el10)"

URI_default-fonts-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ur-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ur = "paktype-naskh-basic-fonts ( )"
RPROVIDES:default-fonts-ur = "metainfo() ( ) font(:lang=ur) ( ) metainfo(org.fedoraproject.default-fonts-ur.metainfo.xml) ( ) default-fonts-ur ( =  4.1-3.el10) langpacks-core-font-ur ( =  4.1-3.el10)"

URI_default-fonts-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ve-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-ve = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-ve = "metainfo() ( ) font(:lang=ve) ( ) metainfo(org.fedoraproject.default-fonts-ve.metainfo.xml) ( ) default-fonts-ve ( =  4.1-3.el10) langpacks-core-font-ve ( =  4.1-3.el10)"

URI_default-fonts-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-vi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-vi = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-vi = "metainfo() ( ) font(:lang=vi) ( ) metainfo(org.fedoraproject.default-fonts-vi.metainfo.xml) ( ) default-fonts-vi ( =  4.1-3.el10) langpacks-core-font-vi ( =  4.1-3.el10)"

URI_default-fonts-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-xh-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-xh = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-xh = "metainfo() ( ) font(:lang=xh) ( ) metainfo(org.fedoraproject.default-fonts-xh.metainfo.xml) ( ) default-fonts-xh ( =  4.1-3.el10) langpacks-core-font-xh ( =  4.1-3.el10)"

URI_default-fonts-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-yi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-yi = "google-noto-sans-hebrew-vf-fonts ( )"
RPROVIDES:default-fonts-yi = "metainfo() ( ) font(:lang=yi) ( ) metainfo(org.fedoraproject.default-fonts-yi.metainfo.xml) ( ) default-fonts-yi ( =  4.1-3.el10) langpacks-core-font-yi ( =  4.1-3.el10)"

URI_default-fonts-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-zu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:default-fonts-zu = "google-noto-sans-vf-fonts ( ) redhat-text-vf-fonts ( )"
RPROVIDES:default-fonts-zu = "metainfo() ( ) font(:lang=zu) ( ) metainfo(org.fedoraproject.default-fonts-zu.metainfo.xml) ( ) default-fonts-zu ( =  4.1-3.el10) langpacks-core-font-zu ( =  4.1-3.el10)"

URI_langpacks-af = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-af-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-af = "langpacks-core-af ( ) langpacks-fonts-af ( )"
RPROVIDES:langpacks-af = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-af.metainfo.xml) ( ) langpacks-af ( =  4.1-3.el10)"

URI_langpacks-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-am-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-am = "langpacks-core-am ( ) langpacks-fonts-am ( )"
RPROVIDES:langpacks-am = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-am.metainfo.xml) ( ) langpacks-am ( =  4.1-3.el10)"

URI_langpacks-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ar-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ar = "langpacks-core-ar ( ) langpacks-fonts-ar ( )"
RPROVIDES:langpacks-ar = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ar.metainfo.xml) ( ) langpacks-ar ( =  4.1-3.el10)"

URI_langpacks-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-as-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-as = "langpacks-core-as ( ) langpacks-fonts-as ( )"
RPROVIDES:langpacks-as = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-as.metainfo.xml) ( ) langpacks-as ( =  4.1-3.el10)"

URI_langpacks-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ast-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ast = "langpacks-core-ast ( ) langpacks-fonts-ast ( )"
RPROVIDES:langpacks-ast = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ast.metainfo.xml) ( ) langpacks-ast ( =  4.1-3.el10)"

URI_langpacks-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-be-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-be = "langpacks-core-be ( ) langpacks-fonts-be ( )"
RPROVIDES:langpacks-be = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-be.metainfo.xml) ( ) langpacks-be ( =  4.1-3.el10)"

URI_langpacks-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bg-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-bg = "langpacks-core-bg ( ) langpacks-fonts-bg ( )"
RPROVIDES:langpacks-bg = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-bg.metainfo.xml) ( ) langpacks-bg ( =  4.1-3.el10)"

URI_langpacks-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-bn = "langpacks-core-bn ( ) langpacks-fonts-bn ( )"
RPROVIDES:langpacks-bn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-bn.metainfo.xml) ( ) langpacks-bn ( =  4.1-3.el10)"

URI_langpacks-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-bo = "langpacks-core-bo ( ) langpacks-fonts-bo ( )"
RPROVIDES:langpacks-bo = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-bo.metainfo.xml) ( ) langpacks-bo ( =  4.1-3.el10)"

URI_langpacks-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-br-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-br = "langpacks-core-br ( ) langpacks-fonts-br ( )"
RPROVIDES:langpacks-br = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-br.metainfo.xml) ( ) langpacks-br ( =  4.1-3.el10)"

URI_langpacks-bs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bs-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-bs = "langpacks-core-bs ( ) langpacks-fonts-bs ( )"
RPROVIDES:langpacks-bs = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-bs.metainfo.xml) ( ) langpacks-bs ( =  4.1-3.el10)"

URI_langpacks-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ca-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ca = "langpacks-core-ca ( ) langpacks-fonts-ca ( )"
RPROVIDES:langpacks-ca = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ca.metainfo.xml) ( ) langpacks-ca ( =  4.1-3.el10)"

URI_langpacks-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-chr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-chr = "langpacks-core-chr ( ) langpacks-fonts-chr ( )"
RPROVIDES:langpacks-chr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-chr.metainfo.xml) ( ) langpacks-chr ( =  4.1-3.el10)"

URI_langpacks-core-af = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-af-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-af = "default-fonts-af ( )"
RPROVIDES:langpacks-core-af = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-af.metainfo.xml) ( ) langpacks-core-af ( =  4.1-3.el10)"

URI_langpacks-core-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-am-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-am = "default-fonts-am ( )"
RPROVIDES:langpacks-core-am = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-am.metainfo.xml) ( ) langpacks-core-am ( =  4.1-3.el10)"

URI_langpacks-core-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ar-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ar = "default-fonts-ar ( )"
RPROVIDES:langpacks-core-ar = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ar.metainfo.xml) ( ) langpacks-core-ar ( =  4.1-3.el10)"

URI_langpacks-core-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-as-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-as = "default-fonts-as ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-as = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-as.metainfo.xml) ( ) langpacks-core-as ( =  4.1-3.el10)"

URI_langpacks-core-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ast-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ast = "default-fonts-ast ( )"
RPROVIDES:langpacks-core-ast = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ast.metainfo.xml) ( ) langpacks-core-ast ( =  4.1-3.el10)"

URI_langpacks-core-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-be-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-be = "default-fonts-be ( )"
RPROVIDES:langpacks-core-be = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-be.metainfo.xml) ( ) langpacks-core-be ( =  4.1-3.el10)"

URI_langpacks-core-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bg-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-bg = "default-fonts-bg ( )"
RPROVIDES:langpacks-core-bg = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-bg.metainfo.xml) ( ) langpacks-core-bg ( =  4.1-3.el10)"

URI_langpacks-core-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-bn = "default-fonts-bn ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-bn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-bn.metainfo.xml) ( ) langpacks-core-bn ( =  4.1-3.el10)"

URI_langpacks-core-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-bo = "default-fonts-bo ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-bo = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-bo.metainfo.xml) ( ) langpacks-core-bo ( =  4.1-3.el10)"

URI_langpacks-core-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-br-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-br = "default-fonts-br ( )"
RPROVIDES:langpacks-core-br = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-br.metainfo.xml) ( ) langpacks-core-br ( =  4.1-3.el10)"

URI_langpacks-core-bs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bs-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-bs = "default-fonts-bs ( )"
RPROVIDES:langpacks-core-bs = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-bs.metainfo.xml) ( ) langpacks-core-bs ( =  4.1-3.el10)"

URI_langpacks-core-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ca-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ca = "default-fonts-ca ( )"
RPROVIDES:langpacks-core-ca = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ca.metainfo.xml) ( ) langpacks-core-ca ( =  4.1-3.el10)"

URI_langpacks-core-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-chr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-chr = "default-fonts-chr ( )"
RPROVIDES:langpacks-core-chr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-chr.metainfo.xml) ( ) langpacks-core-chr ( =  4.1-3.el10)"

URI_langpacks-core-cs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-cs-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-cs = "default-fonts-cs ( )"
RPROVIDES:langpacks-core-cs = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-cs.metainfo.xml) ( ) langpacks-core-cs ( =  4.1-3.el10)"

URI_langpacks-core-cy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-cy-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-cy = "default-fonts-cy ( )"
RPROVIDES:langpacks-core-cy = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-cy.metainfo.xml) ( ) langpacks-core-cy ( =  4.1-3.el10)"

URI_langpacks-core-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-da-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-da = "default-fonts-da ( )"
RPROVIDES:langpacks-core-da = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-da.metainfo.xml) ( ) langpacks-core-da ( =  4.1-3.el10)"

URI_langpacks-core-de = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-de-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-de = "default-fonts-de ( )"
RPROVIDES:langpacks-core-de = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-de.metainfo.xml) ( ) langpacks-core-de ( =  4.1-3.el10)"

URI_langpacks-core-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-dv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-dv = "default-fonts-dv ( )"
RPROVIDES:langpacks-core-dv = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-dv.metainfo.xml) ( ) langpacks-core-dv ( =  4.1-3.el10)"

URI_langpacks-core-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-dz-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-dz = "default-fonts-dz ( )"
RPROVIDES:langpacks-core-dz = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-dz.metainfo.xml) ( ) langpacks-core-dz ( =  4.1-3.el10)"

URI_langpacks-core-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-el-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-el = "default-fonts-el ( )"
RPROVIDES:langpacks-core-el = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-el.metainfo.xml) ( ) langpacks-core-el ( =  4.1-3.el10)"

URI_langpacks-core-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-en-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-en = "default-fonts-en ( )"
RPROVIDES:langpacks-core-en = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-en.metainfo.xml) ( ) langpacks-core-en ( =  4.1-3.el10)"

URI_langpacks-core-en_GB = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-en_GB-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-en_GB = "default-fonts-en ( )"
RPROVIDES:langpacks-core-en_GB = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-en_GB.metainfo.xml) ( ) langpacks-core-en_GB ( =  4.1-3.el10)"

URI_langpacks-core-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-eo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-eo = "default-fonts-eo ( )"
RPROVIDES:langpacks-core-eo = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-eo.metainfo.xml) ( ) langpacks-core-eo ( =  4.1-3.el10)"

URI_langpacks-core-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-es-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-es = "default-fonts-es ( )"
RPROVIDES:langpacks-core-es = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-es.metainfo.xml) ( ) langpacks-core-es ( =  4.1-3.el10)"

URI_langpacks-core-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-et-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-et = "default-fonts-et ( )"
RPROVIDES:langpacks-core-et = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-et.metainfo.xml) ( ) langpacks-core-et ( =  4.1-3.el10)"

URI_langpacks-core-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-eu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-eu = "default-fonts-eu ( )"
RPROVIDES:langpacks-core-eu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-eu.metainfo.xml) ( ) langpacks-core-eu ( =  4.1-3.el10)"

URI_langpacks-core-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-fa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-fa = "default-fonts-fa ( )"
RPROVIDES:langpacks-core-fa = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-fa.metainfo.xml) ( ) langpacks-core-fa ( =  4.1-3.el10)"

URI_langpacks-core-fi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-fi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-fi = "default-fonts-fi ( )"
RPROVIDES:langpacks-core-fi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-fi.metainfo.xml) ( ) langpacks-core-fi ( =  4.1-3.el10)"

URI_langpacks-core-fr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-fr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-fr = "default-fonts-fr ( )"
RPROVIDES:langpacks-core-fr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-fr.metainfo.xml) ( ) langpacks-core-fr ( =  4.1-3.el10)"

URI_langpacks-core-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ga-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ga = "default-fonts-ga ( )"
RPROVIDES:langpacks-core-ga = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ga.metainfo.xml) ( ) langpacks-core-ga ( =  4.1-3.el10)"

URI_langpacks-core-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-gl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-gl = "default-fonts-gl ( )"
RPROVIDES:langpacks-core-gl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-gl.metainfo.xml) ( ) langpacks-core-gl ( =  4.1-3.el10)"

URI_langpacks-core-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-gu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-gu = "default-fonts-gu ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-gu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-gu.metainfo.xml) ( ) langpacks-core-gu ( =  4.1-3.el10)"

URI_langpacks-core-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-he-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-he = "default-fonts-he ( )"
RPROVIDES:langpacks-core-he = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-he.metainfo.xml) ( ) langpacks-core-he ( =  4.1-3.el10)"

URI_langpacks-core-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-hi = "default-fonts-hi ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-hi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-hi.metainfo.xml) ( ) langpacks-core-hi ( =  4.1-3.el10)"

URI_langpacks-core-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-hr = "default-fonts-hr ( )"
RPROVIDES:langpacks-core-hr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-hr.metainfo.xml) ( ) langpacks-core-hr ( =  4.1-3.el10)"

URI_langpacks-core-hu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-hu = "default-fonts-hu ( )"
RPROVIDES:langpacks-core-hu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-hu.metainfo.xml) ( ) langpacks-core-hu ( =  4.1-3.el10)"

URI_langpacks-core-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hy-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-hy = "default-fonts-hy ( )"
RPROVIDES:langpacks-core-hy = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-hy.metainfo.xml) ( ) langpacks-core-hy ( =  4.1-3.el10)"

URI_langpacks-core-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ia-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ia = "default-fonts-ia ( )"
RPROVIDES:langpacks-core-ia = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ia.metainfo.xml) ( ) langpacks-core-ia ( =  4.1-3.el10)"

URI_langpacks-core-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-id-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-id = "default-fonts-id ( )"
RPROVIDES:langpacks-core-id = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-id.metainfo.xml) ( ) langpacks-core-id ( =  4.1-3.el10)"

URI_langpacks-core-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-is-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-is = "default-fonts-is ( )"
RPROVIDES:langpacks-core-is = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-is.metainfo.xml) ( ) langpacks-core-is ( =  4.1-3.el10)"

URI_langpacks-core-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-it-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-it = "default-fonts-it ( )"
RPROVIDES:langpacks-core-it = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-it.metainfo.xml) ( ) langpacks-core-it ( =  4.1-3.el10)"

URI_langpacks-core-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-iu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-iu = "default-fonts-iu ( )"
RPROVIDES:langpacks-core-iu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-iu.metainfo.xml) ( ) langpacks-core-iu ( =  4.1-3.el10)"

URI_langpacks-core-ja = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ja-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ja = "default-fonts-ja ( ) ibus-anthy ( if  service(graphical-login))"
RPROVIDES:langpacks-core-ja = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ja.metainfo.xml) ( ) langpacks-core-ja ( =  4.1-3.el10)"

URI_langpacks-core-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ka-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ka = "default-fonts-ka ( )"
RPROVIDES:langpacks-core-ka = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ka.metainfo.xml) ( ) langpacks-core-ka ( =  4.1-3.el10)"

URI_langpacks-core-kk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-kk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-kk = "default-fonts-kk ( )"
RPROVIDES:langpacks-core-kk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-kk.metainfo.xml) ( ) langpacks-core-kk ( =  4.1-3.el10)"

URI_langpacks-core-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-km-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-km = "default-fonts-km ( )"
RPROVIDES:langpacks-core-km = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-km.metainfo.xml) ( ) langpacks-core-km ( =  4.1-3.el10)"

URI_langpacks-core-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-kn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-kn = "default-fonts-kn ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-kn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-kn.metainfo.xml) ( ) langpacks-core-kn ( =  4.1-3.el10)"

URI_langpacks-core-ko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ko-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ko = "default-fonts-ko ( ) ibus-hangul ( if  service(graphical-login))"
RPROVIDES:langpacks-core-ko = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ko.metainfo.xml) ( ) langpacks-core-ko ( =  4.1-3.el10)"

URI_langpacks-core-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ku-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ku = "default-fonts-ku ( )"
RPROVIDES:langpacks-core-ku = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ku.metainfo.xml) ( ) langpacks-core-ku ( =  4.1-3.el10)"

URI_langpacks-core-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-lo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-lo = "default-fonts-lo ( )"
RPROVIDES:langpacks-core-lo = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-lo.metainfo.xml) ( ) langpacks-core-lo ( =  4.1-3.el10)"

URI_langpacks-core-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-lt-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-lt = "default-fonts-lt ( )"
RPROVIDES:langpacks-core-lt = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-lt.metainfo.xml) ( ) langpacks-core-lt ( =  4.1-3.el10)"

URI_langpacks-core-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-lv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-lv = "default-fonts-lv ( )"
RPROVIDES:langpacks-core-lv = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-lv.metainfo.xml) ( ) langpacks-core-lv ( =  4.1-3.el10)"

URI_langpacks-core-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mai-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-mai = "default-fonts-mai ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-mai = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-mai.metainfo.xml) ( ) langpacks-core-mai ( =  4.1-3.el10)"

URI_langpacks-core-mk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-mk = "default-fonts-mk ( )"
RPROVIDES:langpacks-core-mk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-mk.metainfo.xml) ( ) langpacks-core-mk ( =  4.1-3.el10)"

URI_langpacks-core-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ml-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ml = "default-fonts-ml ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-ml = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ml.metainfo.xml) ( ) langpacks-core-ml ( =  4.1-3.el10)"

URI_langpacks-core-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mni-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-mni = "default-fonts-mni ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-mni = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-mni.metainfo.xml) ( ) langpacks-core-mni ( =  4.1-3.el10)"

URI_langpacks-core-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-mr = "default-fonts-mr ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-mr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-mr.metainfo.xml) ( ) langpacks-core-mr ( =  4.1-3.el10)"

URI_langpacks-core-ms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ms-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ms = "default-fonts-ms ( )"
RPROVIDES:langpacks-core-ms = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ms.metainfo.xml) ( ) langpacks-core-ms ( =  4.1-3.el10)"

URI_langpacks-core-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-my-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-my = "default-fonts-my ( )"
RPROVIDES:langpacks-core-my = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-my.metainfo.xml) ( ) langpacks-core-my ( =  4.1-3.el10)"

URI_langpacks-core-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nb-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-nb = "default-fonts-nb ( )"
RPROVIDES:langpacks-core-nb = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-nb.metainfo.xml) ( ) langpacks-core-nb ( =  4.1-3.el10)"

URI_langpacks-core-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ne-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ne = "default-fonts-ne ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-ne = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ne.metainfo.xml) ( ) langpacks-core-ne ( =  4.1-3.el10)"

URI_langpacks-core-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-nl = "default-fonts-nl ( )"
RPROVIDES:langpacks-core-nl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-nl.metainfo.xml) ( ) langpacks-core-nl ( =  4.1-3.el10)"

URI_langpacks-core-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-nn = "default-fonts-nn ( )"
RPROVIDES:langpacks-core-nn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-nn.metainfo.xml) ( ) langpacks-core-nn ( =  4.1-3.el10)"

URI_langpacks-core-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-nr = "default-fonts-nr ( )"
RPROVIDES:langpacks-core-nr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-nr.metainfo.xml) ( ) langpacks-core-nr ( =  4.1-3.el10)"

URI_langpacks-core-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nso-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-nso = "default-fonts-nso ( )"
RPROVIDES:langpacks-core-nso = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-nso.metainfo.xml) ( ) langpacks-core-nso ( =  4.1-3.el10)"

URI_langpacks-core-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-or-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-or = "default-fonts-or ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-or = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-or.metainfo.xml) ( ) langpacks-core-or ( =  4.1-3.el10)"

URI_langpacks-core-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-pa = "default-fonts-pa ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-pa = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-pa.metainfo.xml) ( ) langpacks-core-pa ( =  4.1-3.el10)"

URI_langpacks-core-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-pl = "default-fonts-pl ( )"
RPROVIDES:langpacks-core-pl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-pl.metainfo.xml) ( ) langpacks-core-pl ( =  4.1-3.el10)"

URI_langpacks-core-pt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pt-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-pt = "default-fonts-pt ( )"
RPROVIDES:langpacks-core-pt = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-pt.metainfo.xml) ( ) langpacks-core-pt ( =  4.1-3.el10)"

URI_langpacks-core-pt_BR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pt_BR-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-pt_BR = "default-fonts-pt ( )"
RPROVIDES:langpacks-core-pt_BR = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-pt_BR.metainfo.xml) ( ) langpacks-core-pt_BR ( =  4.1-3.el10)"

URI_langpacks-core-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ro-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ro = "default-fonts-ro ( )"
RPROVIDES:langpacks-core-ro = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ro.metainfo.xml) ( ) langpacks-core-ro ( =  4.1-3.el10)"

URI_langpacks-core-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ru-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ru = "default-fonts-ru ( )"
RPROVIDES:langpacks-core-ru = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ru.metainfo.xml) ( ) langpacks-core-ru ( =  4.1-3.el10)"

URI_langpacks-core-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sat-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-sat = "default-fonts-sat ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-sat = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-sat.metainfo.xml) ( ) langpacks-core-sat ( =  4.1-3.el10)"

URI_langpacks-core-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-si-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-si = "default-fonts-si ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-si = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-si.metainfo.xml) ( ) langpacks-core-si ( =  4.1-3.el10)"

URI_langpacks-core-sk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-sk = "default-fonts-sk ( )"
RPROVIDES:langpacks-core-sk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-sk.metainfo.xml) ( ) langpacks-core-sk ( =  4.1-3.el10)"

URI_langpacks-core-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-sl = "default-fonts-sl ( )"
RPROVIDES:langpacks-core-sl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-sl.metainfo.xml) ( ) langpacks-core-sl ( =  4.1-3.el10)"

URI_langpacks-core-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sq-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-sq = "default-fonts-sq ( )"
RPROVIDES:langpacks-core-sq = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-sq.metainfo.xml) ( ) langpacks-core-sq ( =  4.1-3.el10)"

URI_langpacks-core-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-sr = "default-fonts-sr ( )"
RPROVIDES:langpacks-core-sr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-sr.metainfo.xml) ( ) langpacks-core-sr ( =  4.1-3.el10)"

URI_langpacks-core-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ss-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ss = "default-fonts-ss ( )"
RPROVIDES:langpacks-core-ss = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ss.metainfo.xml) ( ) langpacks-core-ss ( =  4.1-3.el10)"

URI_langpacks-core-sv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-sv = "default-fonts-sv ( )"
RPROVIDES:langpacks-core-sv = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-sv.metainfo.xml) ( ) langpacks-core-sv ( =  4.1-3.el10)"

URI_langpacks-core-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ta-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ta = "default-fonts-ta ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-ta = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ta.metainfo.xml) ( ) langpacks-core-ta ( =  4.1-3.el10)"

URI_langpacks-core-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-te-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-te = "default-fonts-te ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-te = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-te.metainfo.xml) ( ) langpacks-core-te ( =  4.1-3.el10)"

URI_langpacks-core-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-th-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-th = "default-fonts-th ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-th = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-th.metainfo.xml) ( ) langpacks-core-th ( =  4.1-3.el10)"

URI_langpacks-core-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-tn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-tn = "default-fonts-tn ( )"
RPROVIDES:langpacks-core-tn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-tn.metainfo.xml) ( ) langpacks-core-tn ( =  4.1-3.el10)"

URI_langpacks-core-tr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-tr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-tr = "default-fonts-tr ( )"
RPROVIDES:langpacks-core-tr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-tr.metainfo.xml) ( ) langpacks-core-tr ( =  4.1-3.el10)"

URI_langpacks-core-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ts-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ts = "default-fonts-ts ( )"
RPROVIDES:langpacks-core-ts = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ts.metainfo.xml) ( ) langpacks-core-ts ( =  4.1-3.el10)"

URI_langpacks-core-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-uk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-uk = "default-fonts-uk ( )"
RPROVIDES:langpacks-core-uk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-uk.metainfo.xml) ( ) langpacks-core-uk ( =  4.1-3.el10)"

URI_langpacks-core-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ur-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ur = "default-fonts-ur ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-ur = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ur.metainfo.xml) ( ) langpacks-core-ur ( =  4.1-3.el10)"

URI_langpacks-core-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ve-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-ve = "default-fonts-ve ( )"
RPROVIDES:langpacks-core-ve = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-ve.metainfo.xml) ( ) langpacks-core-ve ( =  4.1-3.el10)"

URI_langpacks-core-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-vi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-vi = "default-fonts-vi ( ) ibus-m17n ( if  service(graphical-login))"
RPROVIDES:langpacks-core-vi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-vi.metainfo.xml) ( ) langpacks-core-vi ( =  4.1-3.el10)"

URI_langpacks-core-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-xh-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-xh = "default-fonts-xh ( )"
RPROVIDES:langpacks-core-xh = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-xh.metainfo.xml) ( ) langpacks-core-xh ( =  4.1-3.el10)"

URI_langpacks-core-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-yi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-yi = "default-fonts-yi ( )"
RPROVIDES:langpacks-core-yi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-yi.metainfo.xml) ( ) langpacks-core-yi ( =  4.1-3.el10)"

URI_langpacks-core-zh_CN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zh_CN-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-zh_CN = "default-fonts-zh_CN ( ) ibus-libpinyin ( if  service(graphical-login))"
RPROVIDES:langpacks-core-zh_CN = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-zh_CN.metainfo.xml) ( ) langpacks-core-zh_CN ( =  4.1-3.el10)"

URI_langpacks-core-zh_HK = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zh_HK-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-zh_HK = "default-fonts-zh_HK ( ) ibus-table-chinese-cangjie ( if  service(graphical-login))"
RPROVIDES:langpacks-core-zh_HK = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-zh_HK.metainfo.xml) ( ) langpacks-core-zh_HK ( =  4.1-3.el10)"

URI_langpacks-core-zh_TW = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zh_TW-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-zh_TW = "default-fonts-zh_TW ( ) ibus-libzhuyin ( if  service(graphical-login))"
RPROVIDES:langpacks-core-zh_TW = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-zh_TW.metainfo.xml) ( ) langpacks-core-zh_TW ( =  4.1-3.el10)"

URI_langpacks-core-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-core-zu = "default-fonts-zu ( )"
RPROVIDES:langpacks-core-zu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-Core-zu.metainfo.xml) ( ) langpacks-core-zu ( =  4.1-3.el10)"

URI_langpacks-cs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-cs-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-cs = "langpacks-core-cs ( ) langpacks-fonts-cs ( )"
RPROVIDES:langpacks-cs = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-cs.metainfo.xml) ( ) langpacks-cs ( =  4.1-3.el10)"

URI_langpacks-cy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-cy-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-cy = "langpacks-core-cy ( ) langpacks-fonts-cy ( )"
RPROVIDES:langpacks-cy = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-cy.metainfo.xml) ( ) langpacks-cy ( =  4.1-3.el10)"

URI_langpacks-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-da-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-da = "langpacks-core-da ( ) langpacks-fonts-da ( )"
RPROVIDES:langpacks-da = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-da.metainfo.xml) ( ) langpacks-da ( =  4.1-3.el10)"

URI_langpacks-de = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-de-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-de = "langpacks-core-de ( ) langpacks-fonts-de ( )"
RPROVIDES:langpacks-de = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-de.metainfo.xml) ( ) langpacks-de ( =  4.1-3.el10)"

URI_langpacks-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-dv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-dv = "langpacks-core-dv ( ) langpacks-fonts-dv ( )"
RPROVIDES:langpacks-dv = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-dv.metainfo.xml) ( ) langpacks-dv ( =  4.1-3.el10)"

URI_langpacks-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-dz-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-dz = "langpacks-core-dz ( ) langpacks-fonts-dz ( )"
RPROVIDES:langpacks-dz = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-dz.metainfo.xml) ( ) langpacks-dz ( =  4.1-3.el10)"

URI_langpacks-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-el-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-el = "langpacks-core-el ( ) langpacks-fonts-el ( )"
RPROVIDES:langpacks-el = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-el.metainfo.xml) ( ) langpacks-el ( =  4.1-3.el10)"

URI_langpacks-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-en-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-en = "langpacks-fonts-en ( ) langpacks-core-en ( )"
RPROVIDES:langpacks-en = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-en.metainfo.xml) ( ) langpacks-en ( =  4.1-3.el10)"

URI_langpacks-en_GB = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-en_GB-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-en_GB = "langpacks-fonts-en ( ) langpacks-core-en_GB ( )"
RPROVIDES:langpacks-en_GB = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-en_GB.metainfo.xml) ( ) langpacks-en_GB ( =  4.1-3.el10)"

URI_langpacks-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-eo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-eo = "langpacks-core-eo ( ) langpacks-fonts-eo ( )"
RPROVIDES:langpacks-eo = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-eo.metainfo.xml) ( ) langpacks-eo ( =  4.1-3.el10)"

URI_langpacks-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-es-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-es = "langpacks-core-es ( ) langpacks-fonts-es ( )"
RPROVIDES:langpacks-es = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-es.metainfo.xml) ( ) langpacks-es ( =  4.1-3.el10)"

URI_langpacks-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-et-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-et = "langpacks-core-et ( ) langpacks-fonts-et ( )"
RPROVIDES:langpacks-et = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-et.metainfo.xml) ( ) langpacks-et ( =  4.1-3.el10)"

URI_langpacks-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-eu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-eu = "langpacks-core-eu ( ) langpacks-fonts-eu ( )"
RPROVIDES:langpacks-eu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-eu.metainfo.xml) ( ) langpacks-eu ( =  4.1-3.el10)"

URI_langpacks-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fa = "langpacks-core-fa ( ) langpacks-fonts-fa ( )"
RPROVIDES:langpacks-fa = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-fa.metainfo.xml) ( ) langpacks-fa ( =  4.1-3.el10)"

URI_langpacks-fi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fi = "langpacks-core-fi ( ) langpacks-fonts-fi ( )"
RPROVIDES:langpacks-fi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-fi.metainfo.xml) ( ) langpacks-fi ( =  4.1-3.el10)"

URI_langpacks-fonts-af = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-af-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-af = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-af ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-af = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-af.metainfo.xml) ( ) default-fonts-extra-af ( =  4.1-3.el10) langpacks-fonts-af ( =  4.1-3.el10)"

URI_langpacks-fonts-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-am-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-am = "google-noto-serif-ethiopic-vf-fonts ( ) default-fonts-am ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-am = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-am.metainfo.xml) ( ) default-fonts-extra-am ( =  4.1-3.el10) langpacks-fonts-am ( =  4.1-3.el10)"

URI_langpacks-fonts-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ar-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ar = "google-noto-naskh-arabic-vf-fonts ( ) default-fonts-ar ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ar = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ar.metainfo.xml) ( ) default-fonts-extra-ar ( =  4.1-3.el10) langpacks-fonts-ar ( =  4.1-3.el10)"

URI_langpacks-fonts-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-as-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-as = "google-noto-serif-bengali-vf-fonts ( ) default-fonts-as ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-as = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-as.metainfo.xml) ( ) default-fonts-extra-as ( =  4.1-3.el10) langpacks-fonts-as ( =  4.1-3.el10)"

URI_langpacks-fonts-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ast-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ast = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ast ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ast = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ast.metainfo.xml) ( ) default-fonts-extra-ast ( =  4.1-3.el10) langpacks-fonts-ast ( =  4.1-3.el10)"

URI_langpacks-fonts-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-be-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-be = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-be ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-be = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-be.metainfo.xml) ( ) default-fonts-extra-be ( =  4.1-3.el10) langpacks-fonts-be ( =  4.1-3.el10)"

URI_langpacks-fonts-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bg-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-bg = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-bg ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-bg = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-bg.metainfo.xml) ( ) default-fonts-extra-bg ( =  4.1-3.el10) langpacks-fonts-bg ( =  4.1-3.el10)"

URI_langpacks-fonts-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-bn = "google-noto-serif-bengali-vf-fonts ( ) default-fonts-bn ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-bn = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-bn.metainfo.xml) ( ) default-fonts-extra-bn ( =  4.1-3.el10) langpacks-fonts-bn ( =  4.1-3.el10)"

URI_langpacks-fonts-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-bo = "default-fonts-bo ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-bo = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-bo.metainfo.xml) ( ) default-fonts-extra-bo ( =  4.1-3.el10) langpacks-fonts-bo ( =  4.1-3.el10)"

URI_langpacks-fonts-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-br-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-br = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-br ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-br = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-br.metainfo.xml) ( ) default-fonts-extra-br ( =  4.1-3.el10) langpacks-fonts-br ( =  4.1-3.el10)"

URI_langpacks-fonts-bs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bs-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-bs = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-bs ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-bs = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-bs.metainfo.xml) ( ) default-fonts-extra-bs ( =  4.1-3.el10) langpacks-fonts-bs ( =  4.1-3.el10)"

URI_langpacks-fonts-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ca-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ca = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ca ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ca = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ca.metainfo.xml) ( ) default-fonts-extra-ca ( =  4.1-3.el10) langpacks-fonts-ca ( =  4.1-3.el10)"

URI_langpacks-fonts-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-chr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-chr = "default-fonts-chr ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-chr = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-chr.metainfo.xml) ( ) default-fonts-extra-chr ( =  4.1-3.el10) langpacks-fonts-chr ( =  4.1-3.el10)"

URI_langpacks-fonts-cs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-cs-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-cs = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-cs ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-cs = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-cs.metainfo.xml) ( ) default-fonts-extra-cs ( =  4.1-3.el10) langpacks-fonts-cs ( =  4.1-3.el10)"

URI_langpacks-fonts-cy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-cy-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-cy = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-cy ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-cy = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-cy.metainfo.xml) ( ) default-fonts-extra-cy ( =  4.1-3.el10) langpacks-fonts-cy ( =  4.1-3.el10)"

URI_langpacks-fonts-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-da-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-da = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-da ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-da = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-da.metainfo.xml) ( ) default-fonts-extra-da ( =  4.1-3.el10) langpacks-fonts-da ( =  4.1-3.el10)"

URI_langpacks-fonts-de = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-de-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-de = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-de ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-de = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-de.metainfo.xml) ( ) default-fonts-extra-de ( =  4.1-3.el10) langpacks-fonts-de ( =  4.1-3.el10)"

URI_langpacks-fonts-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-dv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-dv = "default-fonts-dv ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-dv = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-dv.metainfo.xml) ( ) default-fonts-extra-dv ( =  4.1-3.el10) langpacks-fonts-dv ( =  4.1-3.el10)"

URI_langpacks-fonts-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-dz-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-dz = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-dz ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-dz = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-dz.metainfo.xml) ( ) default-fonts-extra-dz ( =  4.1-3.el10) langpacks-fonts-dz ( =  4.1-3.el10)"

URI_langpacks-fonts-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-el-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-el = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-el ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-el = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-el.metainfo.xml) ( ) default-fonts-extra-el ( =  4.1-3.el10) langpacks-fonts-el ( =  4.1-3.el10)"

URI_langpacks-fonts-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-en-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-en = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-en ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-en = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-en.metainfo.xml) ( ) default-fonts-extra-en ( =  4.1-3.el10) langpacks-fonts-en ( =  4.1-3.el10)"

URI_langpacks-fonts-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-eo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-eo = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-eo ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-eo = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-eo.metainfo.xml) ( ) default-fonts-extra-eo ( =  4.1-3.el10) langpacks-fonts-eo ( =  4.1-3.el10)"

URI_langpacks-fonts-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-es-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-es = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-es ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-es = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-es.metainfo.xml) ( ) default-fonts-extra-es ( =  4.1-3.el10) langpacks-fonts-es ( =  4.1-3.el10)"

URI_langpacks-fonts-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-et-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-et = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-et ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-et = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-et.metainfo.xml) ( ) default-fonts-extra-et ( =  4.1-3.el10) langpacks-fonts-et ( =  4.1-3.el10)"

URI_langpacks-fonts-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-eu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-eu = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-eu ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-eu = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-eu.metainfo.xml) ( ) default-fonts-extra-eu ( =  4.1-3.el10) langpacks-fonts-eu ( =  4.1-3.el10)"

URI_langpacks-fonts-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-fa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-fa = "google-noto-naskh-arabic-vf-fonts ( ) default-fonts-fa ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-fa = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-fa.metainfo.xml) ( ) default-fonts-extra-fa ( =  4.1-3.el10) langpacks-fonts-fa ( =  4.1-3.el10)"

URI_langpacks-fonts-fi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-fi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-fi = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-fi ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-fi = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-fi.metainfo.xml) ( ) default-fonts-extra-fi ( =  4.1-3.el10) langpacks-fonts-fi ( =  4.1-3.el10)"

URI_langpacks-fonts-fr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-fr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-fr = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-fr ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-fr = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-fr.metainfo.xml) ( ) default-fonts-extra-fr ( =  4.1-3.el10) langpacks-fonts-fr ( =  4.1-3.el10)"

URI_langpacks-fonts-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ga-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ga = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ga ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ga = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ga.metainfo.xml) ( ) default-fonts-extra-ga ( =  4.1-3.el10) langpacks-fonts-ga ( =  4.1-3.el10)"

URI_langpacks-fonts-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-gl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-gl = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-gl ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-gl = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-gl.metainfo.xml) ( ) default-fonts-extra-gl ( =  4.1-3.el10) langpacks-fonts-gl ( =  4.1-3.el10)"

URI_langpacks-fonts-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-gu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-gu = "google-noto-serif-gujarati-vf-fonts ( ) default-fonts-gu ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-gu = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-gu.metainfo.xml) ( ) default-fonts-extra-gu ( =  4.1-3.el10) langpacks-fonts-gu ( =  4.1-3.el10)"

URI_langpacks-fonts-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-he-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-he = "google-noto-serif-hebrew-vf-fonts ( ) default-fonts-he ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-he = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-he.metainfo.xml) ( ) default-fonts-extra-he ( =  4.1-3.el10) langpacks-fonts-he ( =  4.1-3.el10)"

URI_langpacks-fonts-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-hi = "google-noto-serif-devanagari-vf-fonts ( ) default-fonts-hi ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-hi = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-hi.metainfo.xml) ( ) default-fonts-extra-hi ( =  4.1-3.el10) langpacks-fonts-hi ( =  4.1-3.el10)"

URI_langpacks-fonts-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-hr = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-hr ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-hr = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-hr.metainfo.xml) ( ) default-fonts-extra-hr ( =  4.1-3.el10) langpacks-fonts-hr ( =  4.1-3.el10)"

URI_langpacks-fonts-hu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-hu = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-hu ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-hu = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-hu.metainfo.xml) ( ) default-fonts-extra-hu ( =  4.1-3.el10) langpacks-fonts-hu ( =  4.1-3.el10)"

URI_langpacks-fonts-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hy-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-hy = "google-noto-serif-armenian-vf-fonts ( ) default-fonts-hy ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-hy = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-hy.metainfo.xml) ( ) default-fonts-extra-hy ( =  4.1-3.el10) langpacks-fonts-hy ( =  4.1-3.el10)"

URI_langpacks-fonts-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ia-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ia = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ia ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ia = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ia.metainfo.xml) ( ) default-fonts-extra-ia ( =  4.1-3.el10) langpacks-fonts-ia ( =  4.1-3.el10)"

URI_langpacks-fonts-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-id-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-id = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-id ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-id = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-id.metainfo.xml) ( ) default-fonts-extra-id ( =  4.1-3.el10) langpacks-fonts-id ( =  4.1-3.el10)"

URI_langpacks-fonts-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-is-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-is = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-is ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-is = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-is.metainfo.xml) ( ) default-fonts-extra-is ( =  4.1-3.el10) langpacks-fonts-is ( =  4.1-3.el10)"

URI_langpacks-fonts-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-it-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-it = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-it ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-it = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-it.metainfo.xml) ( ) default-fonts-extra-it ( =  4.1-3.el10) langpacks-fonts-it ( =  4.1-3.el10)"

URI_langpacks-fonts-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-iu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-iu = "default-fonts-iu ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-iu = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-iu.metainfo.xml) ( ) default-fonts-extra-iu ( =  4.1-3.el10) langpacks-fonts-iu ( =  4.1-3.el10)"

URI_langpacks-fonts-ja = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ja-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ja = "google-noto-sans-mono-cjk-vf-fonts ( ) google-noto-serif-cjk-vf-fonts ( ) default-fonts-ja ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ja = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ja.metainfo.xml) ( ) default-fonts-extra-ja ( =  4.1-3.el10) langpacks-fonts-ja ( =  4.1-3.el10)"

URI_langpacks-fonts-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ka-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ka = "google-noto-serif-georgian-vf-fonts ( ) default-fonts-ka ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ka = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ka.metainfo.xml) ( ) default-fonts-extra-ka ( =  4.1-3.el10) langpacks-fonts-ka ( =  4.1-3.el10)"

URI_langpacks-fonts-kk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-kk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-kk = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-kk ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-kk = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-kk.metainfo.xml) ( ) default-fonts-extra-kk ( =  4.1-3.el10) langpacks-fonts-kk ( =  4.1-3.el10)"

URI_langpacks-fonts-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-km-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-km = "google-noto-serif-khmer-vf-fonts ( ) default-fonts-km ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-km = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-km.metainfo.xml) ( ) default-fonts-extra-km ( =  4.1-3.el10) langpacks-fonts-km ( =  4.1-3.el10)"

URI_langpacks-fonts-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-kn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-kn = "google-noto-serif-kannada-vf-fonts ( ) default-fonts-kn ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-kn = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-kn.metainfo.xml) ( ) default-fonts-extra-kn ( =  4.1-3.el10) langpacks-fonts-kn ( =  4.1-3.el10)"

URI_langpacks-fonts-ko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ko-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ko = "google-noto-sans-mono-cjk-vf-fonts ( ) google-noto-serif-cjk-vf-fonts ( ) default-fonts-ko ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ko = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ko.metainfo.xml) ( ) default-fonts-extra-ko ( =  4.1-3.el10) langpacks-fonts-ko ( =  4.1-3.el10)"

URI_langpacks-fonts-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ku-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ku = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ku ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ku = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ku.metainfo.xml) ( ) default-fonts-extra-ku ( =  4.1-3.el10) langpacks-fonts-ku ( =  4.1-3.el10)"

URI_langpacks-fonts-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-lo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-lo = "google-noto-serif-lao-vf-fonts ( ) default-fonts-lo ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-lo = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-lo.metainfo.xml) ( ) default-fonts-extra-lo ( =  4.1-3.el10) langpacks-fonts-lo ( =  4.1-3.el10)"

URI_langpacks-fonts-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-lt-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-lt = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-lt ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-lt = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-lt.metainfo.xml) ( ) default-fonts-extra-lt ( =  4.1-3.el10) langpacks-fonts-lt ( =  4.1-3.el10)"

URI_langpacks-fonts-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-lv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-lv = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-lv ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-lv = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-lv.metainfo.xml) ( ) default-fonts-extra-lv ( =  4.1-3.el10) langpacks-fonts-lv ( =  4.1-3.el10)"

URI_langpacks-fonts-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mai-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-mai = "google-noto-serif-devanagari-vf-fonts ( ) default-fonts-mai ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-mai = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-mai.metainfo.xml) ( ) default-fonts-extra-mai ( =  4.1-3.el10) langpacks-fonts-mai ( =  4.1-3.el10)"

URI_langpacks-fonts-mk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-mk = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-mk ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-mk = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-mk.metainfo.xml) ( ) default-fonts-extra-mk ( =  4.1-3.el10) langpacks-fonts-mk ( =  4.1-3.el10)"

URI_langpacks-fonts-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ml-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ml = "rit-rachana-fonts ( ) default-fonts-ml ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ml = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ml.metainfo.xml) ( ) default-fonts-extra-ml ( =  4.1-3.el10) langpacks-fonts-ml ( =  4.1-3.el10)"

URI_langpacks-fonts-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mni-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-mni = "default-fonts-mni ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-mni = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-mni.metainfo.xml) ( ) default-fonts-extra-mni ( =  4.1-3.el10) langpacks-fonts-mni ( =  4.1-3.el10)"

URI_langpacks-fonts-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-mr = "google-noto-serif-devanagari-vf-fonts ( ) default-fonts-mr ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-mr = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-mr.metainfo.xml) ( ) default-fonts-extra-mr ( =  4.1-3.el10) langpacks-fonts-mr ( =  4.1-3.el10)"

URI_langpacks-fonts-ms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ms-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ms = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ms ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ms = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ms.metainfo.xml) ( ) default-fonts-extra-ms ( =  4.1-3.el10) langpacks-fonts-ms ( =  4.1-3.el10)"

URI_langpacks-fonts-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-my-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-my = "default-fonts-my ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-my = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-my.metainfo.xml) ( ) default-fonts-extra-my ( =  4.1-3.el10) langpacks-fonts-my ( =  4.1-3.el10)"

URI_langpacks-fonts-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nb-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-nb = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-nb ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-nb = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-nb.metainfo.xml) ( ) default-fonts-extra-nb ( =  4.1-3.el10) langpacks-fonts-nb ( =  4.1-3.el10)"

URI_langpacks-fonts-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ne-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ne = "default-fonts-ne ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ne = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ne.metainfo.xml) ( ) default-fonts-extra-ne ( =  4.1-3.el10) langpacks-fonts-ne ( =  4.1-3.el10)"

URI_langpacks-fonts-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-nl = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-nl ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-nl = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-nl.metainfo.xml) ( ) default-fonts-extra-nl ( =  4.1-3.el10) langpacks-fonts-nl ( =  4.1-3.el10)"

URI_langpacks-fonts-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-nn = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-nn ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-nn = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-nn.metainfo.xml) ( ) default-fonts-extra-nn ( =  4.1-3.el10) langpacks-fonts-nn ( =  4.1-3.el10)"

URI_langpacks-fonts-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-nr = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-nr ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-nr = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-nr.metainfo.xml) ( ) default-fonts-extra-nr ( =  4.1-3.el10) langpacks-fonts-nr ( =  4.1-3.el10)"

URI_langpacks-fonts-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nso-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-nso = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-nso ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-nso = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-nso.metainfo.xml) ( ) default-fonts-extra-nso ( =  4.1-3.el10) langpacks-fonts-nso ( =  4.1-3.el10)"

URI_langpacks-fonts-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-or-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-or = "google-noto-serif-oriya-vf-fonts ( ) default-fonts-or ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-or = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-or.metainfo.xml) ( ) default-fonts-extra-or ( =  4.1-3.el10) langpacks-fonts-or ( =  4.1-3.el10)"

URI_langpacks-fonts-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-pa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-pa = "google-noto-serif-gurmukhi-vf-fonts ( ) default-fonts-pa ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-pa = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-pa.metainfo.xml) ( ) default-fonts-extra-pa ( =  4.1-3.el10) langpacks-fonts-pa ( =  4.1-3.el10)"

URI_langpacks-fonts-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-pl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-pl = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-pl ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-pl = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-pl.metainfo.xml) ( ) default-fonts-extra-pl ( =  4.1-3.el10) langpacks-fonts-pl ( =  4.1-3.el10)"

URI_langpacks-fonts-pt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-pt-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-pt = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-pt ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-pt = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-pt.metainfo.xml) ( ) default-fonts-extra-pt ( =  4.1-3.el10) langpacks-fonts-pt ( =  4.1-3.el10)"

URI_langpacks-fonts-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ro-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ro = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ro ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ro = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ro.metainfo.xml) ( ) default-fonts-extra-ro ( =  4.1-3.el10) langpacks-fonts-ro ( =  4.1-3.el10)"

URI_langpacks-fonts-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ru-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ru = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ru ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ru = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ru.metainfo.xml) ( ) default-fonts-extra-ru ( =  4.1-3.el10) langpacks-fonts-ru ( =  4.1-3.el10)"

URI_langpacks-fonts-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sat-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-sat = "default-fonts-sat ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-sat = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-sat.metainfo.xml) ( ) default-fonts-extra-sat ( =  4.1-3.el10) langpacks-fonts-sat ( =  4.1-3.el10)"

URI_langpacks-fonts-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-si-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-si = "google-noto-serif-sinhala-vf-fonts ( ) default-fonts-si ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-si = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-si.metainfo.xml) ( ) default-fonts-extra-si ( =  4.1-3.el10) langpacks-fonts-si ( =  4.1-3.el10)"

URI_langpacks-fonts-sk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-sk = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-sk ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-sk = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-sk.metainfo.xml) ( ) default-fonts-extra-sk ( =  4.1-3.el10) langpacks-fonts-sk ( =  4.1-3.el10)"

URI_langpacks-fonts-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-sl = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-sl ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-sl = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-sl.metainfo.xml) ( ) default-fonts-extra-sl ( =  4.1-3.el10) langpacks-fonts-sl ( =  4.1-3.el10)"

URI_langpacks-fonts-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sq-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-sq = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-sq ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-sq = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-sq.metainfo.xml) ( ) default-fonts-extra-sq ( =  4.1-3.el10) langpacks-fonts-sq ( =  4.1-3.el10)"

URI_langpacks-fonts-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-sr = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-sr ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-sr = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-sr.metainfo.xml) ( ) default-fonts-extra-sr ( =  4.1-3.el10) langpacks-fonts-sr ( =  4.1-3.el10)"

URI_langpacks-fonts-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ss-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ss = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ss ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ss = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ss.metainfo.xml) ( ) default-fonts-extra-ss ( =  4.1-3.el10) langpacks-fonts-ss ( =  4.1-3.el10)"

URI_langpacks-fonts-sv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-sv = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-sv ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-sv = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-sv.metainfo.xml) ( ) default-fonts-extra-sv ( =  4.1-3.el10) langpacks-fonts-sv ( =  4.1-3.el10)"

URI_langpacks-fonts-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ta-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ta = "google-noto-serif-tamil-vf-fonts ( ) default-fonts-ta ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ta = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ta.metainfo.xml) ( ) default-fonts-extra-ta ( =  4.1-3.el10) langpacks-fonts-ta ( =  4.1-3.el10)"

URI_langpacks-fonts-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-te-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-te = "google-noto-serif-telugu-vf-fonts ( ) default-fonts-te ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-te = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-te.metainfo.xml) ( ) default-fonts-extra-te ( =  4.1-3.el10) langpacks-fonts-te ( =  4.1-3.el10)"

URI_langpacks-fonts-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-th-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-th = "google-noto-serif-thai-vf-fonts ( ) default-fonts-th ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-th = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-th.metainfo.xml) ( ) default-fonts-extra-th ( =  4.1-3.el10) langpacks-fonts-th ( =  4.1-3.el10)"

URI_langpacks-fonts-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-tn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-tn = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-tn ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-tn = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-tn.metainfo.xml) ( ) default-fonts-extra-tn ( =  4.1-3.el10) langpacks-fonts-tn ( =  4.1-3.el10)"

URI_langpacks-fonts-tr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-tr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-tr = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-tr ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-tr = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-tr.metainfo.xml) ( ) default-fonts-extra-tr ( =  4.1-3.el10) langpacks-fonts-tr ( =  4.1-3.el10)"

URI_langpacks-fonts-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ts-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ts = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ts ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ts = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ts.metainfo.xml) ( ) default-fonts-extra-ts ( =  4.1-3.el10) langpacks-fonts-ts ( =  4.1-3.el10)"

URI_langpacks-fonts-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-uk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-uk = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-uk ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-uk = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-uk.metainfo.xml) ( ) default-fonts-extra-uk ( =  4.1-3.el10) langpacks-fonts-uk ( =  4.1-3.el10)"

URI_langpacks-fonts-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ur-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ur = "google-noto-naskh-arabic-vf-fonts ( ) default-fonts-ur ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ur = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ur.metainfo.xml) ( ) default-fonts-extra-ur ( =  4.1-3.el10) langpacks-fonts-ur ( =  4.1-3.el10)"

URI_langpacks-fonts-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ve-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-ve = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-ve ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-ve = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-ve.metainfo.xml) ( ) default-fonts-extra-ve ( =  4.1-3.el10) langpacks-fonts-ve ( =  4.1-3.el10)"

URI_langpacks-fonts-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-vi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-vi = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-vi ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-vi = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-vi.metainfo.xml) ( ) default-fonts-extra-vi ( =  4.1-3.el10) langpacks-fonts-vi ( =  4.1-3.el10)"

URI_langpacks-fonts-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-xh-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-xh = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-xh ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-xh = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-xh.metainfo.xml) ( ) default-fonts-extra-xh ( =  4.1-3.el10) langpacks-fonts-xh ( =  4.1-3.el10)"

URI_langpacks-fonts-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-yi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-yi = "google-noto-serif-hebrew-vf-fonts ( ) default-fonts-yi ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-yi = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-yi.metainfo.xml) ( ) default-fonts-extra-yi ( =  4.1-3.el10) langpacks-fonts-yi ( =  4.1-3.el10)"

URI_langpacks-fonts-zh_CN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zh_CN-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-zh_CN = "google-noto-sans-mono-cjk-vf-fonts ( ) google-noto-serif-cjk-vf-fonts ( ) default-fonts-zh_CN ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-zh_CN = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-zh_CN.metainfo.xml) ( ) default-fonts-extra-zh_CN ( =  4.1-3.el10) langpacks-fonts-zh_CN ( =  4.1-3.el10)"

URI_langpacks-fonts-zh_HK = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zh_HK-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-zh_HK = "google-noto-sans-mono-cjk-vf-fonts ( ) google-noto-serif-cjk-vf-fonts ( ) default-fonts-zh_HK ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-zh_HK = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-zh_HK.metainfo.xml) ( ) default-fonts-extra-zh_HK ( =  4.1-3.el10) langpacks-fonts-zh_HK ( =  4.1-3.el10)"

URI_langpacks-fonts-zh_TW = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zh_TW-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-zh_TW = "google-noto-sans-mono-cjk-vf-fonts ( ) google-noto-serif-cjk-vf-fonts ( ) default-fonts-zh_TW ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-zh_TW = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-zh_TW.metainfo.xml) ( ) default-fonts-extra-zh_TW ( =  4.1-3.el10) langpacks-fonts-zh_TW ( =  4.1-3.el10)"

URI_langpacks-fonts-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fonts-zu = "google-noto-sans-mono-vf-fonts ( ) google-noto-serif-vf-fonts ( ) redhat-mono-vf-fonts ( ) default-fonts-zu ( =  4.1-3.el10)"
RPROVIDES:langpacks-fonts-zu = "metainfo() ( ) metainfo(org.fedoraproject.langpacks-fonts-zu.metainfo.xml) ( ) default-fonts-extra-zu ( =  4.1-3.el10) langpacks-fonts-zu ( =  4.1-3.el10)"

URI_langpacks-fr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-fr = "langpacks-core-fr ( ) langpacks-fonts-fr ( )"
RPROVIDES:langpacks-fr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-fr.metainfo.xml) ( ) langpacks-fr ( =  4.1-3.el10)"

URI_langpacks-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ga-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ga = "langpacks-core-ga ( ) langpacks-fonts-ga ( )"
RPROVIDES:langpacks-ga = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ga.metainfo.xml) ( ) langpacks-ga ( =  4.1-3.el10)"

URI_langpacks-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-gl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-gl = "langpacks-core-gl ( ) langpacks-fonts-gl ( )"
RPROVIDES:langpacks-gl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-gl.metainfo.xml) ( ) langpacks-gl ( =  4.1-3.el10)"

URI_langpacks-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-gu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-gu = "langpacks-core-gu ( ) langpacks-fonts-gu ( )"
RPROVIDES:langpacks-gu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-gu.metainfo.xml) ( ) langpacks-gu ( =  4.1-3.el10)"

URI_langpacks-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-he-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-he = "langpacks-core-he ( ) langpacks-fonts-he ( )"
RPROVIDES:langpacks-he = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-he.metainfo.xml) ( ) langpacks-he ( =  4.1-3.el10)"

URI_langpacks-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-hi = "langpacks-core-hi ( ) langpacks-fonts-hi ( )"
RPROVIDES:langpacks-hi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-hi.metainfo.xml) ( ) langpacks-hi ( =  4.1-3.el10)"

URI_langpacks-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-hr = "langpacks-core-hr ( ) langpacks-fonts-hr ( )"
RPROVIDES:langpacks-hr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-hr.metainfo.xml) ( ) langpacks-hr ( =  4.1-3.el10)"

URI_langpacks-hu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-hu = "langpacks-core-hu ( ) langpacks-fonts-hu ( )"
RPROVIDES:langpacks-hu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-hu.metainfo.xml) ( ) langpacks-hu ( =  4.1-3.el10)"

URI_langpacks-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hy-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-hy = "langpacks-core-hy ( ) langpacks-fonts-hy ( )"
RPROVIDES:langpacks-hy = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-hy.metainfo.xml) ( ) langpacks-hy ( =  4.1-3.el10)"

URI_langpacks-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ia-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ia = "langpacks-core-ia ( ) langpacks-fonts-ia ( )"
RPROVIDES:langpacks-ia = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ia.metainfo.xml) ( ) langpacks-ia ( =  4.1-3.el10)"

URI_langpacks-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-id-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-id = "langpacks-core-id ( ) langpacks-fonts-id ( )"
RPROVIDES:langpacks-id = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-id.metainfo.xml) ( ) langpacks-id ( =  4.1-3.el10)"

URI_langpacks-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-is-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-is = "langpacks-core-is ( ) langpacks-fonts-is ( )"
RPROVIDES:langpacks-is = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-is.metainfo.xml) ( ) langpacks-is ( =  4.1-3.el10)"

URI_langpacks-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-it-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-it = "langpacks-core-it ( ) langpacks-fonts-it ( )"
RPROVIDES:langpacks-it = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-it.metainfo.xml) ( ) langpacks-it ( =  4.1-3.el10)"

URI_langpacks-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-iu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-iu = "langpacks-core-iu ( ) langpacks-fonts-iu ( )"
RPROVIDES:langpacks-iu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-iu.metainfo.xml) ( ) langpacks-iu ( =  4.1-3.el10)"

URI_langpacks-ja = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ja-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ja = "langpacks-core-ja ( ) langpacks-fonts-ja ( )"
RPROVIDES:langpacks-ja = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ja.metainfo.xml) ( ) langpacks-ja ( =  4.1-3.el10)"

URI_langpacks-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ka-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ka = "langpacks-core-ka ( ) langpacks-fonts-ka ( )"
RPROVIDES:langpacks-ka = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ka.metainfo.xml) ( ) langpacks-ka ( =  4.1-3.el10)"

URI_langpacks-kk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-kk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-kk = "langpacks-core-kk ( ) langpacks-fonts-kk ( )"
RPROVIDES:langpacks-kk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-kk.metainfo.xml) ( ) langpacks-kk ( =  4.1-3.el10)"

URI_langpacks-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-km-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-km = "langpacks-core-km ( ) langpacks-fonts-km ( )"
RPROVIDES:langpacks-km = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-km.metainfo.xml) ( ) langpacks-km ( =  4.1-3.el10)"

URI_langpacks-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-kn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-kn = "langpacks-core-kn ( ) langpacks-fonts-kn ( )"
RPROVIDES:langpacks-kn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-kn.metainfo.xml) ( ) langpacks-kn ( =  4.1-3.el10)"

URI_langpacks-ko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ko-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ko = "langpacks-core-ko ( ) langpacks-fonts-ko ( )"
RPROVIDES:langpacks-ko = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ko.metainfo.xml) ( ) langpacks-ko ( =  4.1-3.el10)"

URI_langpacks-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ku-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ku = "langpacks-core-ku ( ) langpacks-fonts-ku ( )"
RPROVIDES:langpacks-ku = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ku.metainfo.xml) ( ) langpacks-ku ( =  4.1-3.el10)"

URI_langpacks-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-lo-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-lo = "langpacks-core-lo ( ) langpacks-fonts-lo ( )"
RPROVIDES:langpacks-lo = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-lo.metainfo.xml) ( ) langpacks-lo ( =  4.1-3.el10)"

URI_langpacks-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-lt-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-lt = "langpacks-core-lt ( ) langpacks-fonts-lt ( )"
RPROVIDES:langpacks-lt = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-lt.metainfo.xml) ( ) langpacks-lt ( =  4.1-3.el10)"

URI_langpacks-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-lv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-lv = "langpacks-core-lv ( ) langpacks-fonts-lv ( )"
RPROVIDES:langpacks-lv = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-lv.metainfo.xml) ( ) langpacks-lv ( =  4.1-3.el10)"

URI_langpacks-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mai-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-mai = "langpacks-core-mai ( ) langpacks-fonts-mai ( )"
RPROVIDES:langpacks-mai = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-mai.metainfo.xml) ( ) langpacks-mai ( =  4.1-3.el10)"

URI_langpacks-mk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-mk = "langpacks-core-mk ( ) langpacks-fonts-mk ( )"
RPROVIDES:langpacks-mk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-mk.metainfo.xml) ( ) langpacks-mk ( =  4.1-3.el10)"

URI_langpacks-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ml-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ml = "langpacks-core-ml ( ) langpacks-fonts-ml ( )"
RPROVIDES:langpacks-ml = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ml.metainfo.xml) ( ) langpacks-ml ( =  4.1-3.el10)"

URI_langpacks-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mni-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-mni = "langpacks-core-mni ( ) langpacks-fonts-mni ( )"
RPROVIDES:langpacks-mni = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-mni.metainfo.xml) ( ) langpacks-mni ( =  4.1-3.el10)"

URI_langpacks-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-mr = "langpacks-core-mr ( ) langpacks-fonts-mr ( )"
RPROVIDES:langpacks-mr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-mr.metainfo.xml) ( ) langpacks-mr ( =  4.1-3.el10)"

URI_langpacks-ms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ms-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ms = "langpacks-core-ms ( ) langpacks-fonts-ms ( )"
RPROVIDES:langpacks-ms = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ms.metainfo.xml) ( ) langpacks-ms ( =  4.1-3.el10)"

URI_langpacks-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-my-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-my = "langpacks-core-my ( ) langpacks-fonts-my ( )"
RPROVIDES:langpacks-my = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-my.metainfo.xml) ( ) langpacks-my ( =  4.1-3.el10)"

URI_langpacks-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nb-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-nb = "langpacks-core-nb ( ) langpacks-fonts-nb ( )"
RPROVIDES:langpacks-nb = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-nb.metainfo.xml) ( ) langpacks-nb ( =  4.1-3.el10)"

URI_langpacks-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ne-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ne = "langpacks-core-ne ( ) langpacks-fonts-ne ( )"
RPROVIDES:langpacks-ne = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ne.metainfo.xml) ( ) langpacks-ne ( =  4.1-3.el10)"

URI_langpacks-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-nl = "langpacks-core-nl ( ) langpacks-fonts-nl ( )"
RPROVIDES:langpacks-nl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-nl.metainfo.xml) ( ) langpacks-nl ( =  4.1-3.el10)"

URI_langpacks-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-nn = "langpacks-core-nn ( ) langpacks-fonts-nn ( )"
RPROVIDES:langpacks-nn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-nn.metainfo.xml) ( ) langpacks-nn ( =  4.1-3.el10)"

URI_langpacks-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-nr = "langpacks-core-nr ( ) langpacks-fonts-nr ( )"
RPROVIDES:langpacks-nr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-nr.metainfo.xml) ( ) langpacks-nr ( =  4.1-3.el10)"

URI_langpacks-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nso-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-nso = "langpacks-core-nso ( ) langpacks-fonts-nso ( )"
RPROVIDES:langpacks-nso = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-nso.metainfo.xml) ( ) langpacks-nso ( =  4.1-3.el10)"

URI_langpacks-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-or-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-or = "langpacks-core-or ( ) langpacks-fonts-or ( )"
RPROVIDES:langpacks-or = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-or.metainfo.xml) ( ) langpacks-or ( =  4.1-3.el10)"

URI_langpacks-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pa-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-pa = "langpacks-core-pa ( ) langpacks-fonts-pa ( )"
RPROVIDES:langpacks-pa = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-pa.metainfo.xml) ( ) langpacks-pa ( =  4.1-3.el10)"

URI_langpacks-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-pl = "langpacks-core-pl ( ) langpacks-fonts-pl ( )"
RPROVIDES:langpacks-pl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-pl.metainfo.xml) ( ) langpacks-pl ( =  4.1-3.el10)"

URI_langpacks-pt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pt-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-pt = "langpacks-fonts-pt ( ) langpacks-core-pt ( )"
RPROVIDES:langpacks-pt = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-pt.metainfo.xml) ( ) langpacks-pt ( =  4.1-3.el10)"

URI_langpacks-pt_BR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pt_BR-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-pt_BR = "langpacks-fonts-pt ( ) langpacks-core-pt_BR ( )"
RPROVIDES:langpacks-pt_BR = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-pt_BR.metainfo.xml) ( ) langpacks-pt_BR ( =  4.1-3.el10)"

URI_langpacks-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ro-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ro = "langpacks-core-ro ( ) langpacks-fonts-ro ( )"
RPROVIDES:langpacks-ro = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ro.metainfo.xml) ( ) langpacks-ro ( =  4.1-3.el10)"

URI_langpacks-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ru-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ru = "langpacks-core-ru ( ) langpacks-fonts-ru ( )"
RPROVIDES:langpacks-ru = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ru.metainfo.xml) ( ) langpacks-ru ( =  4.1-3.el10)"

URI_langpacks-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sat-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-sat = "langpacks-core-sat ( ) langpacks-fonts-sat ( )"
RPROVIDES:langpacks-sat = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-sat.metainfo.xml) ( ) langpacks-sat ( =  4.1-3.el10)"

URI_langpacks-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-si-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-si = "langpacks-core-si ( ) langpacks-fonts-si ( )"
RPROVIDES:langpacks-si = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-si.metainfo.xml) ( ) langpacks-si ( =  4.1-3.el10)"

URI_langpacks-sk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-sk = "langpacks-core-sk ( ) langpacks-fonts-sk ( )"
RPROVIDES:langpacks-sk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-sk.metainfo.xml) ( ) langpacks-sk ( =  4.1-3.el10)"

URI_langpacks-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sl-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-sl = "langpacks-core-sl ( ) langpacks-fonts-sl ( )"
RPROVIDES:langpacks-sl = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-sl.metainfo.xml) ( ) langpacks-sl ( =  4.1-3.el10)"

URI_langpacks-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sq-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-sq = "langpacks-core-sq ( ) langpacks-fonts-sq ( )"
RPROVIDES:langpacks-sq = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-sq.metainfo.xml) ( ) langpacks-sq ( =  4.1-3.el10)"

URI_langpacks-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-sr = "langpacks-core-sr ( ) langpacks-fonts-sr ( )"
RPROVIDES:langpacks-sr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-sr.metainfo.xml) ( ) langpacks-sr ( =  4.1-3.el10)"

URI_langpacks-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ss-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ss = "langpacks-core-ss ( ) langpacks-fonts-ss ( )"
RPROVIDES:langpacks-ss = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ss.metainfo.xml) ( ) langpacks-ss ( =  4.1-3.el10)"

URI_langpacks-sv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sv-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-sv = "langpacks-core-sv ( ) langpacks-fonts-sv ( )"
RPROVIDES:langpacks-sv = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-sv.metainfo.xml) ( ) langpacks-sv ( =  4.1-3.el10)"

URI_langpacks-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ta-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ta = "langpacks-core-ta ( ) langpacks-fonts-ta ( )"
RPROVIDES:langpacks-ta = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ta.metainfo.xml) ( ) langpacks-ta ( =  4.1-3.el10)"

URI_langpacks-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-te-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-te = "langpacks-core-te ( ) langpacks-fonts-te ( )"
RPROVIDES:langpacks-te = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-te.metainfo.xml) ( ) langpacks-te ( =  4.1-3.el10)"

URI_langpacks-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-th-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-th = "langpacks-core-th ( ) langpacks-fonts-th ( )"
RPROVIDES:langpacks-th = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-th.metainfo.xml) ( ) langpacks-th ( =  4.1-3.el10)"

URI_langpacks-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-tn-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-tn = "langpacks-core-tn ( ) langpacks-fonts-tn ( )"
RPROVIDES:langpacks-tn = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-tn.metainfo.xml) ( ) langpacks-tn ( =  4.1-3.el10)"

URI_langpacks-tr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-tr-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-tr = "langpacks-core-tr ( ) langpacks-fonts-tr ( )"
RPROVIDES:langpacks-tr = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-tr.metainfo.xml) ( ) langpacks-tr ( =  4.1-3.el10)"

URI_langpacks-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ts-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ts = "langpacks-core-ts ( ) langpacks-fonts-ts ( )"
RPROVIDES:langpacks-ts = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ts.metainfo.xml) ( ) langpacks-ts ( =  4.1-3.el10)"

URI_langpacks-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-uk-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-uk = "langpacks-core-uk ( ) langpacks-fonts-uk ( )"
RPROVIDES:langpacks-uk = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-uk.metainfo.xml) ( ) langpacks-uk ( =  4.1-3.el10)"

URI_langpacks-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ur-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ur = "langpacks-core-ur ( ) langpacks-fonts-ur ( )"
RPROVIDES:langpacks-ur = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ur.metainfo.xml) ( ) langpacks-ur ( =  4.1-3.el10)"

URI_langpacks-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ve-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-ve = "langpacks-core-ve ( ) langpacks-fonts-ve ( )"
RPROVIDES:langpacks-ve = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-ve.metainfo.xml) ( ) langpacks-ve ( =  4.1-3.el10)"

URI_langpacks-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-vi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-vi = "langpacks-core-vi ( ) langpacks-fonts-vi ( )"
RPROVIDES:langpacks-vi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-vi.metainfo.xml) ( ) langpacks-vi ( =  4.1-3.el10)"

URI_langpacks-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-xh-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-xh = "langpacks-core-xh ( ) langpacks-fonts-xh ( )"
RPROVIDES:langpacks-xh = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-xh.metainfo.xml) ( ) langpacks-xh ( =  4.1-3.el10)"

URI_langpacks-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-yi-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-yi = "langpacks-core-yi ( ) langpacks-fonts-yi ( )"
RPROVIDES:langpacks-yi = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-yi.metainfo.xml) ( ) langpacks-yi ( =  4.1-3.el10)"

URI_langpacks-zh_CN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zh_CN-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-zh_CN = "langpacks-core-zh_CN ( ) langpacks-fonts-zh_CN ( )"
RPROVIDES:langpacks-zh_CN = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-zh_CN.metainfo.xml) ( ) langpacks-zh_CN ( =  4.1-3.el10)"

URI_langpacks-zh_HK = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zh_HK-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-zh_HK = "langpacks-core-zh_HK ( ) langpacks-fonts-zh_HK ( )"
RPROVIDES:langpacks-zh_HK = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-zh_HK.metainfo.xml) ( ) langpacks-zh_HK ( =  4.1-3.el10)"

URI_langpacks-zh_TW = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zh_TW-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-zh_TW = "langpacks-core-zh_TW ( ) langpacks-fonts-zh_TW ( )"
RPROVIDES:langpacks-zh_TW = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-zh_TW.metainfo.xml) ( ) langpacks-zh_TW ( =  4.1-3.el10)"

URI_langpacks-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zu-4.1-3.el10.noarch.rpm;unpack=0"
RDEPENDS:langpacks-zu = "langpacks-core-zu ( ) langpacks-fonts-zu ( )"
RPROVIDES:langpacks-zu = "metainfo() ( ) metainfo(org.fedoraproject.LangPack-zu.metainfo.xml) ( ) langpacks-zu ( =  4.1-3.el10)"
