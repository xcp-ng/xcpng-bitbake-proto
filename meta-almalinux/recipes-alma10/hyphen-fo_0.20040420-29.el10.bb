
PN = "hyphen-fo"
PE = "0"
PV = "0.20040420"
PR = "29.el10"
PACKAGES = "hyphen-fo"


URI_hyphen-fo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-fo-0.20040420-29.el10.noarch.rpm;unpack=0"
RDEPENDS:hyphen-fo = " \
 hyphen \
"
