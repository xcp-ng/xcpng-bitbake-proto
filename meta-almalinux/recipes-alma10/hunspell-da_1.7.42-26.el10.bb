
PN = "hunspell-da"
PE = "0"
PV = "1.7.42"
PR = "26.el10"
PACKAGES = "hunspell-da"


URI_hunspell-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-da-1.7.42-26.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-da = " \
 hunspell-filesystem \
"
