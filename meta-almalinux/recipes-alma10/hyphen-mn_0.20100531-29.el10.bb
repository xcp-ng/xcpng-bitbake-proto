
PN = "hyphen-mn"
PE = "0"
PV = "0.20100531"
PR = "29.el10"
PACKAGES = "hyphen-mn"


URI_hyphen-mn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-mn-0.20100531-29.el10.noarch.rpm;unpack=0"
RDEPENDS:hyphen-mn = " \
 hyphen \
"
