
PN = "opencl-filesystem"
PE = "0"
PV = "1.0"
PR = "22.el10"
PACKAGES = "opencl-filesystem"


URI_opencl-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/opencl-filesystem-1.0-22.el10.noarch.rpm;unpack=0"
RDEPENDS:opencl-filesystem = ""
