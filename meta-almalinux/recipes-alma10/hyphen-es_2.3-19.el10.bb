
PN = "hyphen-es"
PE = "0"
PV = "2.3"
PR = "19.el10"
PACKAGES = "hyphen-es"


URI_hyphen-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-es-2.3-19.el10.noarch.rpm;unpack=0"
RDEPENDS:hyphen-es = " \
 hyphen \
"
