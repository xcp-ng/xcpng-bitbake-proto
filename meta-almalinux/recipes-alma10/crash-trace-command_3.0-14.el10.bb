
PN = "crash-trace-command"
PE = "0"
PV = "3.0"
PR = "14.el10"
PACKAGES = "crash-trace-command"


URI_crash-trace-command = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/crash-trace-command-3.0-14.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:crash-trace-command = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.4)(64bit) ( ) trace-cmd ( ) crash ( >=  7.2.0-2)"
RPROVIDES:crash-trace-command = "crash-trace-command ( =  3.0-14.el10) crash-trace-command(x86-64) ( =  3.0-14.el10)"
