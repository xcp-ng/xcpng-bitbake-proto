
PN = "perl-Pod-Parser"
PE = "0"
PV = "1.67"
PR = "5.el10"
PACKAGES = "perl-Pod-Parser"


URI_perl-Pod-Parser = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Pod-Parser-1.67-5.el10.noarch.rpm;unpack=0"
RDEPENDS:perl-Pod-Parser = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-interpreter \
 perl-Getopt-Long \
 perl-Pod-Parser \
 perl-PathTools \
 perl-File-Find \
 perl-Exporter \
 perl-Pod-Usage \
"
