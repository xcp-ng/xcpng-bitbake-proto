
PN = "zip"
PE = "0"
PV = "3.0"
PR = "44.el10"
PACKAGES = "zip"


URI_zip = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/zip-3.0-44.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:zip = "
 glibc
 unzip
 bzip2-libs
"
