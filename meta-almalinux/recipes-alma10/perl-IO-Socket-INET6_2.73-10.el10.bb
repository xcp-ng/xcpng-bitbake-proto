
PN = "perl-IO-Socket-INET6"
PE = "0"
PV = "2.73"
PR = "10.el10"
PACKAGES = "perl-IO-Socket-INET6"


URI_perl-IO-Socket-INET6 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-Socket-INET6-2.73-10.el10.noarch.rpm;unpack=0"
RDEPENDS:perl-IO-Socket-INET6 = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Socket \
 perl-Socket6 \
 perl-Errno \
"
