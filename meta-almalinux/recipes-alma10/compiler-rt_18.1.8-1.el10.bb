
inherit dnf-bridge

PN = "compiler-rt"
PE = "0"
PV = "18.1.8"
PR = "1.el10"
PACKAGES = ""

