
PN = "python-linux-procfs"
PE = "0"
PV = "0.7.3"
PR = "7.el10"
PACKAGES = "python3-linux-procfs"


URI_python3-linux-procfs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-linux-procfs-0.7.3-7.el10.noarch.rpm;unpack=0"
RDEPENDS:python3-linux-procfs = "
 python3
 python3-six
"
