
PN = "google-crosextra-caladea-fonts"
PE = "1"
PV = "1.002"
PR = "0.20.20130214.el10"
PACKAGES = ""

