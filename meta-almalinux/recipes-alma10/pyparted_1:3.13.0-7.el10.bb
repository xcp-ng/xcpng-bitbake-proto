
PN = "pyparted"
PE = "1"
PV = "3.13.0"
PR = "7.el10"
PACKAGES = ""

