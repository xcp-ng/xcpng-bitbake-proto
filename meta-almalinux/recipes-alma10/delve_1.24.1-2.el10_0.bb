
PN = "delve"
PE = "0"
PV = "1.24.1"
PR = "2.el10_0"
PACKAGES = "delve"


URI_delve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/delve-1.24.1-2.el10_0.x86_64_v2.rpm;unpack=0"
RDEPENDS:delve = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.34)(64bit) ( ) libresolv.so.2()(64bit) ( )"
RPROVIDES:delve = "bundled(golang(gopkg.in/yaml.v3)) ( =  3.0.1) bundled(golang(github.com/inconshreveable/mousetrap)) ( =  1.1.0) bundled(golang(github.com/spf13/pflag)) ( =  1.0.6) bundled(golang(github.com/mattn/go-colorable)) ( =  0.1.13) bundled(golang(github.com/mattn/go-isatty)) ( =  0.0.20) bundled(golang(github.com/hashicorp/golang-lru)) ( =  1.0.2) bundled(golang(github.com/russross/blackfriday/v2)) ( =  2.1.0) bundled(golang(golang.org/x/mod)) ( =  0.20.0) bundled(golang(github.com/cilium/ebpf)) ( =  0.11.0) bundled(golang(github.com/cosiner/argv)) ( =  0.1.0) bundled(golang(github.com/cpuguy83/go-md2man/v2)) ( =  2.0.6) bundled(golang(github.com/cpuguy83/go.md2man/v2)) ( =  2.0.6) bundled(golang(github.com/creack/pty)) ( =  1.1.20) bundled(golang(github.com/derekparker/trie)) ( =  0.0.0.20230829180723.39f4de51ef7d) bundled(golang(github.com/derekparker/trie)) ( =  39f4de5) bundled(golang(github.com/go-delve/liner)) ( =  4726ab1) bundled(golang(github.com/go.delve/liner)) ( =  1.2.3.0.20231231155935.4726ab1d7f62) bundled(golang(github.com/google/go-dap)) ( =  0.12.0) bundled(golang(github.com/google/go.dap)) ( =  0.12.0) bundled(golang(github.com/hashicorp/golang.lru)) ( =  1.0.2) bundled(golang(github.com/mattn/go-runewidth)) ( =  0.0.13) bundled(golang(github.com/mattn/go.colorable)) ( =  0.1.13) bundled(golang(github.com/mattn/go.isatty)) ( =  0.0.20) bundled(golang(github.com/mattn/go.runewidth)) ( =  0.0.13) bundled(golang(github.com/rivo/uniseg)) ( =  0.2.0) bundled(golang(github.com/spf13/cobra)) ( =  1.9.1) bundled(golang(go.starlark.net)) ( =  0.0.0.20231101134539.556fd59b42f6) bundled(golang(go.starlark.net)) ( =  556fd59) bundled(golang(golang.org/x/arch)) ( =  0.11.0) bundled(golang(golang.org/x/exp)) ( =  0.0.0.20230224173230.c95f2b4c22f2) bundled(golang(golang.org/x/exp)) ( =  c95f2b4) bundled(golang(golang.org/x/sync)) ( =  0.8.0) bundled(golang(golang.org/x/sys)) ( =  0.26.0) bundled(golang(golang.org/x/telemetry)) ( =  0.0.0.20241106142447.58a1122356f5) bundled(golang(golang.org/x/telemetry)) ( =  58a1122) bundled(golang(golang.org/x/tools)) ( =  0.14.0) delve ( =  1.24.1-2.el10_0) delve(x86-64) ( =  1.24.1-2.el10_0)"
