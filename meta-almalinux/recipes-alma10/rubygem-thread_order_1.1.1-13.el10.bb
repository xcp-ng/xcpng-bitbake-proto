
PN = "rubygem-thread_order"
PE = "0"
PV = "1.1.1"
PR = "13.el10"
PACKAGES = "rubygem-thread_order rubygem-thread_order-doc"


URI_rubygem-thread_order = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-thread_order-1.1.1-13.el10.noarch.rpm;unpack=0"
RDEPENDS:rubygem-thread_order = "
 rubygems
"

URI_rubygem-thread_order-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-thread_order-doc-1.1.1-13.el10.noarch.rpm;unpack=0"
RDEPENDS:rubygem-thread_order-doc = "
 rubygem-thread_order
"
