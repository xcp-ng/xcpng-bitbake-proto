
PN = "gnome-connections"
PE = "0"
PV = "47.2.1"
PR = "1.el10"
PACKAGES = "gnome-connections"


URI_gnome-connections = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-connections-47.2.1-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:gnome-connections = "
 libhandy
 fuse3-libs
 freerdp-libs
 libxml2
 libwinpr
 gdk-pixbuf2
 gvnc
 libsecret
 gvncpulse
 cairo
 glib2
 gtk3
 glibc
 gtk-vnc2
 hicolor-icon-theme
"
