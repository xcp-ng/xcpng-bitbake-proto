
PN = "gnome-shell"
PE = "0"
PV = "47.4"
PR = "2.el10.alma.2"
PACKAGES = "gnome-shell"


URI_gnome-shell = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-47.4-2.el10.alma.2.x86_64_v2.rpm;unpack=0"
RDEPENDS:gnome-shell = " \
 python3 \
 gjs \
 systemd-libs \
 xdg-desktop-portal-gnome \
 xdg-desktop-portal-gtk \
 xdg-user-dirs-gtk \
 pango \
 mutter \
 libX11 \
 ibus \
 upower \
 NetworkManager-libnm \
 gnome-autoar \
 libnma-gtk4 \
 libXfixes \
 tecla \
 accountsservice-libs \
 gnome-control-center \
 evolution-data-server \
 gnome-desktop4 \
 gnome-desktop3 \
 json-glib \
 cairo \
 switcheroo-control \
 libadwaita \
 at-spi2-atk \
 gcr \
 gcr-libs \
 gnome-settings-daemon \
 atk \
 gobject-introspection \
 libglvnd-gles \
 pulseaudio-libs \
 librsvg2 \
 libgcc \
 pulseaudio-libs-glib2 \
 gdk-pixbuf2 \
 libsecret \
 gdm \
 graphene \
 geoclue2-libs \
 pipewire-gstreamer \
 pipewire-libs \
 libgweather \
 gstreamer1 \
 libical-glib \
 gsettings-desktop-schemas \
 gettext \
 gstreamer1-plugins-good \
 polkit \
 polkit-libs \
 glib2 \
 glibc \
 gtk4 \
"
