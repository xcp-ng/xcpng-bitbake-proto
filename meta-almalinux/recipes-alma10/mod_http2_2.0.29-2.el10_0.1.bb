
PN = "mod_http2"
PE = "0"
PV = "2.0.29"
PR = "2.el10_0.1"
PACKAGES = "mod_http2"


URI_mod_http2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_http2-2.0.29-2.el10_0.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:mod_http2 = "
 glibc
 openssl-libs
 httpd-core
 libnghttp2
"
