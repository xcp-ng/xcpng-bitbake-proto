
PN = "hunspell-mr"
PE = "1"
PV = "8.0"
PR = "7.el10"
PACKAGES = ""

