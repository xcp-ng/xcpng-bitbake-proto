
PN = "copy-jdk-configs"
PE = "0"
PV = "4.1"
PR = "7.el10"
PACKAGES = "copy-jdk-configs"


URI_copy-jdk-configs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/copy-jdk-configs-4.1-7.el10.noarch.rpm;unpack=0"
RDEPENDS:copy-jdk-configs = " \
 lua \
 lua-posix \
 bash \
 findutils \
"
