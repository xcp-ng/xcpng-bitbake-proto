
PN = "python-pycotap"
PE = "0"
PV = "1.1.0"
PR = "22.el10"
PACKAGES = "python3-pycotap"


URI_python3-pycotap = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pycotap-1.1.0-22.el10.noarch.rpm;unpack=0"
RDEPENDS:python3-pycotap = "
 python3
"
