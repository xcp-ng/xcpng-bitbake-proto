
PN = "hunspell-ti"
PE = "0"
PV = "0.20090911"
PR = "30.el10"
PACKAGES = "hunspell-ti"


URI_hunspell-ti = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ti-0.20090911-30.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-ti = "hunspell-filesystem ( )"
RPROVIDES:hunspell-ti = "hunspell-ti ( =  0.20090911-30.el10)"
