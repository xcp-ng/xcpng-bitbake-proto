
PN = "nfs4-acl-tools"
PE = "0"
PV = "0.4.2"
PR = "7.el10"
PACKAGES = "nfs4-acl-tools"


URI_nfs4-acl-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/nfs4-acl-tools-0.4.2-7.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:nfs4-acl-tools = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( )"
RPROVIDES:nfs4-acl-tools = "nfs4-acl-tools ( =  0.4.2-7.el10) nfs4-acl-tools(x86-64) ( =  0.4.2-7.el10)"
