
PN = "google-noto-fonts"
PE = "0"
PV = "20240401"
PR = "5.el10"
PACKAGES = "google-noto-fonts-common google-noto-sans-mono-vf-fonts google-noto-sans-vf-fonts google-noto-serif-vf-fonts google-noto-fangsong-kss-rotated-fonts google-noto-fangsong-kss-vertical-fonts google-noto-fonts-all google-noto-kufi-arabic-fonts google-noto-kufi-arabic-vf-fonts google-noto-music-fonts google-noto-naskh-arabic-fonts google-noto-naskh-arabic-ui-fonts google-noto-naskh-arabic-ui-vf-fonts google-noto-naskh-arabic-vf-fonts google-noto-nastaliq-urdu-fonts google-noto-nastaliq-urdu-vf-fonts google-noto-rashi-hebrew-fonts google-noto-rashi-hebrew-vf-fonts google-noto-sans-adlam-fonts google-noto-sans-adlam-unjoined-fonts google-noto-sans-adlam-unjoined-vf-fonts google-noto-sans-adlam-vf-fonts google-noto-sans-anatolian-hieroglyphs-fonts google-noto-sans-arabic-fonts google-noto-sans-arabic-vf-fonts google-noto-sans-armenian-fonts google-noto-sans-armenian-vf-fonts google-noto-sans-avestan-fonts google-noto-sans-balinese-fonts google-noto-sans-balinese-vf-fonts google-noto-sans-bamum-fonts google-noto-sans-bamum-vf-fonts google-noto-sans-bassa-vah-fonts google-noto-sans-bassa-vah-vf-fonts google-noto-sans-batak-fonts google-noto-sans-bengali-fonts google-noto-sans-bengali-ui-fonts google-noto-sans-bengali-vf-fonts google-noto-sans-bhaiksuki-fonts google-noto-sans-brahmi-fonts google-noto-sans-buginese-fonts google-noto-sans-buhid-fonts google-noto-sans-canadian-aboriginal-fonts google-noto-sans-canadian-aboriginal-vf-fonts google-noto-sans-carian-fonts google-noto-sans-caucasian-albanian-fonts google-noto-sans-chakma-fonts google-noto-sans-cham-fonts google-noto-sans-cham-vf-fonts google-noto-sans-cherokee-fonts google-noto-sans-cherokee-vf-fonts google-noto-sans-chorasmian-fonts google-noto-sans-coptic-fonts google-noto-sans-cuneiform-fonts google-noto-sans-cypriot-fonts google-noto-sans-cypro-minoan-fonts google-noto-sans-deseret-fonts google-noto-sans-devanagari-fonts google-noto-sans-devanagari-ui-fonts google-noto-sans-devanagari-vf-fonts google-noto-sans-duployan-fonts google-noto-sans-egyptian-hieroglyphs-fonts google-noto-sans-elbasan-fonts google-noto-sans-elymaic-fonts google-noto-sans-ethiopic-fonts google-noto-sans-ethiopic-vf-fonts google-noto-sans-fonts google-noto-sans-georgian-fonts google-noto-sans-georgian-vf-fonts google-noto-sans-glagolitic-fonts google-noto-sans-gothic-fonts google-noto-sans-grantha-fonts google-noto-sans-gujarati-fonts google-noto-sans-gujarati-ui-fonts google-noto-sans-gujarati-vf-fonts google-noto-sans-gunjala-gondi-fonts google-noto-sans-gunjala-gondi-vf-fonts google-noto-sans-gurmukhi-fonts google-noto-sans-gurmukhi-ui-fonts google-noto-sans-gurmukhi-vf-fonts google-noto-sans-hanifi-rohingya-fonts google-noto-sans-hanifi-rohingya-vf-fonts google-noto-sans-hanunoo-fonts google-noto-sans-hatran-fonts google-noto-sans-hebrew-fonts google-noto-sans-hebrew-vf-fonts google-noto-sans-imperial-aramaic-fonts google-noto-sans-indic-siyaq-numbers-fonts google-noto-sans-inscriptional-pahlavi-fonts google-noto-sans-inscriptional-parthian-fonts google-noto-sans-javanese-fonts google-noto-sans-javanese-vf-fonts google-noto-sans-kaithi-fonts google-noto-sans-kannada-fonts google-noto-sans-kannada-ui-fonts google-noto-sans-kannada-ui-vf-fonts google-noto-sans-kannada-vf-fonts google-noto-sans-kawi-fonts google-noto-sans-kawi-vf-fonts google-noto-sans-kayah-li-fonts google-noto-sans-kayah-li-vf-fonts google-noto-sans-kharoshthi-fonts google-noto-sans-khmer-fonts google-noto-sans-khmer-vf-fonts google-noto-sans-khojki-fonts google-noto-sans-khudawadi-fonts google-noto-sans-lao-fonts google-noto-sans-lao-looped-fonts google-noto-sans-lao-looped-vf-fonts google-noto-sans-lao-vf-fonts google-noto-sans-lepcha-fonts google-noto-sans-limbu-fonts google-noto-sans-linear-a-fonts google-noto-sans-linear-b-fonts google-noto-sans-lisu-fonts google-noto-sans-lisu-vf-fonts google-noto-sans-lycian-fonts google-noto-sans-lydian-fonts google-noto-sans-mahajani-fonts google-noto-sans-malayalam-fonts google-noto-sans-malayalam-ui-fonts google-noto-sans-malayalam-ui-vf-fonts google-noto-sans-malayalam-vf-fonts google-noto-sans-mandaic-fonts google-noto-sans-manichaean-fonts google-noto-sans-marchen-fonts google-noto-sans-masaram-gondi-fonts google-noto-sans-math-fonts google-noto-sans-mayan-numerals-fonts google-noto-sans-medefaidrin-fonts google-noto-sans-medefaidrin-vf-fonts google-noto-sans-meetei-mayek-fonts google-noto-sans-meetei-mayek-vf-fonts google-noto-sans-mende-kikakui-fonts google-noto-sans-meroitic-fonts google-noto-sans-miao-fonts google-noto-sans-modi-fonts google-noto-sans-mongolian-fonts google-noto-sans-mono-fonts google-noto-sans-mro-fonts google-noto-sans-multani-fonts google-noto-sans-myanmar-fonts google-noto-sans-myanmar-vf-fonts google-noto-sans-nabataean-fonts google-noto-sans-nag-mundari-fonts google-noto-sans-nag-mundari-vf-fonts google-noto-sans-nandinagari-fonts google-noto-sans-new-tai-lue-fonts google-noto-sans-new-tai-lue-vf-fonts google-noto-sans-newa-fonts google-noto-sans-nko-fonts google-noto-sans-nko-unjoined-fonts google-noto-sans-nko-unjoined-vf-fonts google-noto-sans-nushu-fonts google-noto-sans-ogham-fonts google-noto-sans-ol-chiki-fonts google-noto-sans-ol-chiki-vf-fonts google-noto-sans-old-hungarian-fonts google-noto-sans-old-italic-fonts google-noto-sans-old-north-arabian-fonts google-noto-sans-old-permic-fonts google-noto-sans-old-persian-fonts google-noto-sans-old-sogdian-fonts google-noto-sans-old-south-arabian-fonts google-noto-sans-old-turkic-fonts google-noto-sans-oriya-fonts google-noto-sans-oriya-vf-fonts google-noto-sans-osage-fonts google-noto-sans-osmanya-fonts google-noto-sans-pahawh-hmong-fonts google-noto-sans-palmyrene-fonts google-noto-sans-pau-cin-hau-fonts google-noto-sans-phagspa-fonts google-noto-sans-phoenician-fonts google-noto-sans-psalter-pahlavi-fonts google-noto-sans-rejang-fonts google-noto-sans-runic-fonts google-noto-sans-samaritan-fonts google-noto-sans-saurashtra-fonts google-noto-sans-sharada-fonts google-noto-sans-shavian-fonts google-noto-sans-siddham-fonts google-noto-sans-signwriting-fonts google-noto-sans-sinhala-fonts google-noto-sans-sinhala-ui-fonts google-noto-sans-sinhala-vf-fonts google-noto-sans-sogdian-fonts google-noto-sans-sora-sompeng-fonts google-noto-sans-sora-sompeng-vf-fonts google-noto-sans-soyombo-fonts google-noto-sans-sundanese-fonts google-noto-sans-sundanese-vf-fonts google-noto-sans-syloti-nagri-fonts google-noto-sans-symbols-2-fonts google-noto-sans-symbols-fonts google-noto-sans-symbols-vf-fonts google-noto-sans-syriac-eastern-fonts google-noto-sans-syriac-eastern-vf-fonts google-noto-sans-syriac-fonts google-noto-sans-syriac-vf-fonts google-noto-sans-syriac-western-fonts google-noto-sans-syriac-western-vf-fonts google-noto-sans-tagalog-fonts google-noto-sans-tagbanwa-fonts google-noto-sans-tai-le-fonts google-noto-sans-tai-tham-fonts google-noto-sans-tai-tham-vf-fonts google-noto-sans-tai-viet-fonts google-noto-sans-takri-fonts google-noto-sans-tamil-fonts google-noto-sans-tamil-supplement-fonts google-noto-sans-tamil-ui-fonts google-noto-sans-tamil-ui-vf-fonts google-noto-sans-tamil-vf-fonts google-noto-sans-tangsa-fonts google-noto-sans-tangsa-vf-fonts google-noto-sans-telugu-fonts google-noto-sans-telugu-ui-fonts google-noto-sans-telugu-ui-vf-fonts google-noto-sans-telugu-vf-fonts google-noto-sans-thaana-fonts google-noto-sans-thaana-vf-fonts google-noto-sans-thai-fonts google-noto-sans-thai-looped-fonts google-noto-sans-thai-vf-fonts google-noto-sans-tifinagh-adrar-fonts google-noto-sans-tifinagh-agraw-imazighen-fonts google-noto-sans-tifinagh-ahaggar-fonts google-noto-sans-tifinagh-air-fonts google-noto-sans-tifinagh-apt-fonts google-noto-sans-tifinagh-azawagh-fonts google-noto-sans-tifinagh-fonts google-noto-sans-tifinagh-ghat-fonts google-noto-sans-tifinagh-hawad-fonts google-noto-sans-tifinagh-rhissa-ixa-fonts google-noto-sans-tifinagh-sil-fonts google-noto-sans-tifinagh-tawellemmet-fonts google-noto-sans-tirhuta-fonts google-noto-sans-ugaritic-fonts google-noto-sans-vai-fonts google-noto-sans-vithkuqi-fonts google-noto-sans-vithkuqi-vf-fonts google-noto-sans-wancho-fonts google-noto-sans-warang-citi-fonts google-noto-sans-yi-fonts google-noto-sans-zanabazar-square-fonts google-noto-serif-ahom-fonts google-noto-serif-armenian-fonts google-noto-serif-armenian-vf-fonts google-noto-serif-balinese-fonts google-noto-serif-bengali-fonts google-noto-serif-bengali-vf-fonts google-noto-serif-devanagari-fonts google-noto-serif-devanagari-vf-fonts google-noto-serif-dives-akuru-fonts google-noto-serif-dogra-fonts google-noto-serif-ethiopic-fonts google-noto-serif-ethiopic-vf-fonts google-noto-serif-fonts google-noto-serif-georgian-fonts google-noto-serif-georgian-vf-fonts google-noto-serif-grantha-fonts google-noto-serif-gujarati-fonts google-noto-serif-gujarati-vf-fonts google-noto-serif-gurmukhi-fonts google-noto-serif-gurmukhi-vf-fonts google-noto-serif-hebrew-fonts google-noto-serif-hebrew-vf-fonts google-noto-serif-kannada-fonts google-noto-serif-kannada-vf-fonts google-noto-serif-khitan-small-script-fonts google-noto-serif-khmer-fonts google-noto-serif-khmer-vf-fonts google-noto-serif-khojki-fonts google-noto-serif-khojki-vf-fonts google-noto-serif-lao-fonts google-noto-serif-lao-vf-fonts google-noto-serif-makasar-fonts google-noto-serif-malayalam-fonts google-noto-serif-malayalam-vf-fonts google-noto-serif-myanmar-fonts google-noto-serif-np-hmong-fonts google-noto-serif-np-hmong-vf-fonts google-noto-serif-old-uyghur-fonts google-noto-serif-oriya-fonts google-noto-serif-oriya-vf-fonts google-noto-serif-ottoman-siyaq-fonts google-noto-serif-sinhala-fonts google-noto-serif-sinhala-vf-fonts google-noto-serif-tamil-fonts google-noto-serif-tamil-vf-fonts google-noto-serif-tangut-fonts google-noto-serif-telugu-fonts google-noto-serif-telugu-vf-fonts google-noto-serif-thai-fonts google-noto-serif-thai-vf-fonts google-noto-serif-tibetan-fonts google-noto-serif-tibetan-vf-fonts google-noto-serif-toto-fonts google-noto-serif-toto-vf-fonts google-noto-serif-vithkuqi-fonts google-noto-serif-vithkuqi-vf-fonts google-noto-serif-yezidi-fonts google-noto-serif-yezidi-vf-fonts google-noto-traditional-nushu-fonts google-noto-traditional-nushu-vf-fonts google-noto-fonts-all-static google-noto-fonts-all-vf google-noto-serif-myanmar-vf-fonts"


URI_google-noto-fonts-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-fonts-common-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-fonts-common = ""

URI_google-noto-sans-mono-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-sans-mono-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mono-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-sans-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-serif-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fangsong-kss-rotated-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-fangsong-kss-rotated-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-fangsong-kss-rotated-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fangsong-kss-vertical-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-fangsong-kss-vertical-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-fangsong-kss-vertical-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fonts-all = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-fonts-all-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-fonts-all = " \
 google-noto-sans-khudawadi-fonts \
 google-noto-sans-lao-fonts \
 google-noto-sans-lao-looped-fonts \
 google-noto-sans-lao-looped-vf-fonts \
 google-noto-sans-lao-vf-fonts \
 google-noto-sans-lepcha-fonts \
 google-noto-sans-limbu-fonts \
 google-noto-sans-linear-a-fonts \
 google-noto-sans-linear-b-fonts \
 google-noto-sans-lisu-fonts \
 google-noto-sans-lisu-vf-fonts \
 google-noto-sans-lycian-fonts \
 google-noto-sans-lydian-fonts \
 google-noto-sans-mahajani-fonts \
 google-noto-sans-malayalam-fonts \
 google-noto-sans-malayalam-ui-fonts \
 google-noto-sans-malayalam-ui-vf-fonts \
 google-noto-sans-malayalam-vf-fonts \
 google-noto-sans-mandaic-fonts \
 google-noto-sans-manichaean-fonts \
 google-noto-sans-marchen-fonts \
 google-noto-sans-masaram-gondi-fonts \
 google-noto-sans-math-fonts \
 google-noto-sans-mayan-numerals-fonts \
 google-noto-sans-medefaidrin-fonts \
 google-noto-sans-medefaidrin-vf-fonts \
 google-noto-sans-meetei-mayek-fonts \
 google-noto-sans-meetei-mayek-vf-fonts \
 google-noto-sans-mende-kikakui-fonts \
 google-noto-sans-meroitic-fonts \
 google-noto-sans-miao-fonts \
 google-noto-sans-modi-fonts \
 google-noto-sans-mongolian-fonts \
 google-noto-sans-mono-fonts \
 google-noto-sans-mro-fonts \
 google-noto-sans-multani-fonts \
 google-noto-sans-myanmar-fonts \
 google-noto-sans-myanmar-vf-fonts \
 google-noto-sans-nabataean-fonts \
 google-noto-sans-nag-mundari-fonts \
 google-noto-sans-nag-mundari-vf-fonts \
 google-noto-sans-nandinagari-fonts \
 google-noto-sans-new-tai-lue-fonts \
 google-noto-sans-new-tai-lue-vf-fonts \
 google-noto-sans-newa-fonts \
 google-noto-sans-nko-fonts \
 google-noto-sans-nko-unjoined-fonts \
 google-noto-sans-nko-unjoined-vf-fonts \
 google-noto-sans-nushu-fonts \
 google-noto-sans-ogham-fonts \
 google-noto-sans-ol-chiki-fonts \
 google-noto-sans-ol-chiki-vf-fonts \
 google-noto-sans-old-hungarian-fonts \
 google-noto-sans-old-italic-fonts \
 google-noto-sans-old-north-arabian-fonts \
 google-noto-sans-old-permic-fonts \
 google-noto-sans-old-persian-fonts \
 google-noto-sans-old-sogdian-fonts \
 google-noto-sans-old-south-arabian-fonts \
 google-noto-sans-old-turkic-fonts \
 google-noto-sans-oriya-fonts \
 google-noto-sans-oriya-vf-fonts \
 google-noto-sans-osage-fonts \
 google-noto-sans-osmanya-fonts \
 google-noto-sans-pahawh-hmong-fonts \
 google-noto-sans-palmyrene-fonts \
 google-noto-sans-pau-cin-hau-fonts \
 google-noto-sans-phagspa-fonts \
 google-noto-sans-phoenician-fonts \
 google-noto-sans-psalter-pahlavi-fonts \
 google-noto-sans-rejang-fonts \
 google-noto-sans-runic-fonts \
 google-noto-sans-samaritan-fonts \
 google-noto-sans-saurashtra-fonts \
 google-noto-sans-sharada-fonts \
 google-noto-sans-shavian-fonts \
 google-noto-sans-siddham-fonts \
 google-noto-sans-signwriting-fonts \
 google-noto-sans-sinhala-fonts \
 google-noto-sans-sinhala-ui-fonts \
 google-noto-sans-sinhala-vf-fonts \
 google-noto-sans-sogdian-fonts \
 google-noto-sans-sora-sompeng-fonts \
 google-noto-sans-sora-sompeng-vf-fonts \
 google-noto-sans-soyombo-fonts \
 google-noto-sans-sundanese-fonts \
 google-noto-sans-sundanese-vf-fonts \
 google-noto-sans-syloti-nagri-fonts \
 google-noto-sans-symbols-2-fonts \
 google-noto-sans-symbols-fonts \
 google-noto-sans-symbols-vf-fonts \
 google-noto-sans-syriac-eastern-fonts \
 google-noto-sans-syriac-eastern-vf-fonts \
 google-noto-sans-syriac-fonts \
 google-noto-sans-syriac-vf-fonts \
 google-noto-sans-syriac-western-fonts \
 google-noto-sans-syriac-western-vf-fonts \
 google-noto-sans-tagalog-fonts \
 google-noto-sans-tagbanwa-fonts \
 google-noto-sans-tai-le-fonts \
 google-noto-sans-tai-tham-fonts \
 google-noto-sans-tai-tham-vf-fonts \
 google-noto-sans-tai-viet-fonts \
 google-noto-sans-takri-fonts \
 google-noto-sans-tamil-fonts \
 google-noto-sans-tamil-supplement-fonts \
 google-noto-sans-tamil-ui-fonts \
 google-noto-sans-tamil-ui-vf-fonts \
 google-noto-sans-tamil-vf-fonts \
 google-noto-sans-tangsa-fonts \
 google-noto-sans-tangsa-vf-fonts \
 google-noto-sans-telugu-fonts \
 google-noto-sans-telugu-ui-fonts \
 google-noto-sans-telugu-ui-vf-fonts \
 google-noto-sans-telugu-vf-fonts \
 google-noto-sans-thaana-fonts \
 google-noto-sans-thaana-vf-fonts \
 google-noto-sans-thai-fonts \
 google-noto-sans-thai-looped-fonts \
 google-noto-sans-thai-vf-fonts \
 google-noto-sans-tifinagh-adrar-fonts \
 google-noto-sans-tifinagh-agraw-imazighen-fonts \
 google-noto-sans-tifinagh-ahaggar-fonts \
 google-noto-sans-tifinagh-air-fonts \
 google-noto-sans-tifinagh-apt-fonts \
 google-noto-sans-tifinagh-azawagh-fonts \
 google-noto-sans-tifinagh-fonts \
 google-noto-sans-tifinagh-ghat-fonts \
 google-noto-sans-tifinagh-hawad-fonts \
 google-noto-sans-tifinagh-rhissa-ixa-fonts \
 google-noto-sans-tifinagh-sil-fonts \
 google-noto-sans-tifinagh-tawellemmet-fonts \
 google-noto-sans-tirhuta-fonts \
 google-noto-sans-ugaritic-fonts \
 google-noto-sans-vai-fonts \
 google-noto-sans-vithkuqi-fonts \
 google-noto-sans-vithkuqi-vf-fonts \
 google-noto-sans-wancho-fonts \
 google-noto-sans-warang-citi-fonts \
 google-noto-sans-yi-fonts \
 google-noto-sans-zanabazar-square-fonts \
 google-noto-serif-ahom-fonts \
 google-noto-serif-armenian-fonts \
 google-noto-serif-armenian-vf-fonts \
 google-noto-serif-balinese-fonts \
 google-noto-serif-bengali-fonts \
 google-noto-serif-bengali-vf-fonts \
 google-noto-serif-devanagari-fonts \
 google-noto-serif-devanagari-vf-fonts \
 google-noto-serif-dives-akuru-fonts \
 google-noto-serif-dogra-fonts \
 google-noto-serif-ethiopic-fonts \
 google-noto-serif-ethiopic-vf-fonts \
 google-noto-serif-fonts \
 google-noto-serif-georgian-fonts \
 google-noto-serif-georgian-vf-fonts \
 google-noto-serif-grantha-fonts \
 google-noto-serif-gujarati-fonts \
 google-noto-serif-gujarati-vf-fonts \
 google-noto-serif-gurmukhi-fonts \
 google-noto-serif-gurmukhi-vf-fonts \
 google-noto-serif-hebrew-fonts \
 google-noto-serif-hebrew-vf-fonts \
 google-noto-serif-kannada-fonts \
 google-noto-serif-kannada-vf-fonts \
 google-noto-serif-khitan-small-script-fonts \
 google-noto-serif-khmer-fonts \
 google-noto-serif-khmer-vf-fonts \
 google-noto-serif-khojki-fonts \
 google-noto-serif-khojki-vf-fonts \
 google-noto-serif-lao-fonts \
 google-noto-serif-lao-vf-fonts \
 google-noto-serif-makasar-fonts \
 google-noto-serif-malayalam-fonts \
 google-noto-serif-malayalam-vf-fonts \
 google-noto-serif-myanmar-fonts \
 google-noto-serif-np-hmong-fonts \
 google-noto-serif-np-hmong-vf-fonts \
 google-noto-serif-old-uyghur-fonts \
 google-noto-serif-oriya-fonts \
 google-noto-serif-oriya-vf-fonts \
 google-noto-serif-ottoman-siyaq-fonts \
 google-noto-serif-sinhala-fonts \
 google-noto-serif-sinhala-vf-fonts \
 google-noto-serif-tamil-fonts \
 google-noto-serif-tamil-vf-fonts \
 google-noto-serif-tangut-fonts \
 google-noto-serif-telugu-fonts \
 google-noto-serif-telugu-vf-fonts \
 google-noto-serif-thai-fonts \
 google-noto-serif-thai-vf-fonts \
 google-noto-serif-tibetan-fonts \
 google-noto-serif-tibetan-vf-fonts \
 google-noto-serif-toto-fonts \
 google-noto-serif-toto-vf-fonts \
 google-noto-serif-vithkuqi-fonts \
 google-noto-serif-vithkuqi-vf-fonts \
 google-noto-serif-yezidi-fonts \
 google-noto-serif-yezidi-vf-fonts \
 google-noto-traditional-nushu-fonts \
 google-noto-traditional-nushu-vf-fonts \
 google-noto-sans-mono-vf-fonts \
 google-noto-sans-vf-fonts \
 google-noto-serif-vf-fonts \
 google-noto-fangsong-kss-rotated-fonts \
 google-noto-fangsong-kss-vertical-fonts \
 google-noto-kufi-arabic-fonts \
 google-noto-kufi-arabic-vf-fonts \
 google-noto-music-fonts \
 google-noto-naskh-arabic-fonts \
 google-noto-naskh-arabic-ui-fonts \
 google-noto-naskh-arabic-ui-vf-fonts \
 google-noto-naskh-arabic-vf-fonts \
 google-noto-nastaliq-urdu-fonts \
 google-noto-nastaliq-urdu-vf-fonts \
 google-noto-rashi-hebrew-fonts \
 google-noto-rashi-hebrew-vf-fonts \
 google-noto-sans-adlam-fonts \
 google-noto-sans-adlam-unjoined-fonts \
 google-noto-sans-adlam-unjoined-vf-fonts \
 google-noto-sans-adlam-vf-fonts \
 google-noto-sans-anatolian-hieroglyphs-fonts \
 google-noto-sans-arabic-fonts \
 google-noto-sans-arabic-vf-fonts \
 google-noto-sans-armenian-fonts \
 google-noto-sans-armenian-vf-fonts \
 google-noto-sans-avestan-fonts \
 google-noto-sans-balinese-fonts \
 google-noto-sans-balinese-vf-fonts \
 google-noto-sans-bamum-fonts \
 google-noto-sans-bamum-vf-fonts \
 google-noto-sans-bassa-vah-fonts \
 google-noto-sans-bassa-vah-vf-fonts \
 google-noto-sans-batak-fonts \
 google-noto-sans-bengali-fonts \
 google-noto-sans-bengali-ui-fonts \
 google-noto-sans-bengali-vf-fonts \
 google-noto-sans-bhaiksuki-fonts \
 google-noto-sans-brahmi-fonts \
 google-noto-sans-buginese-fonts \
 google-noto-sans-buhid-fonts \
 google-noto-sans-canadian-aboriginal-fonts \
 google-noto-sans-canadian-aboriginal-vf-fonts \
 google-noto-sans-carian-fonts \
 google-noto-sans-caucasian-albanian-fonts \
 google-noto-sans-chakma-fonts \
 google-noto-sans-cham-fonts \
 google-noto-sans-cham-vf-fonts \
 google-noto-sans-cherokee-fonts \
 google-noto-sans-cherokee-vf-fonts \
 google-noto-sans-chorasmian-fonts \
 google-noto-sans-coptic-fonts \
 google-noto-sans-cuneiform-fonts \
 google-noto-sans-cypriot-fonts \
 google-noto-sans-cypro-minoan-fonts \
 google-noto-sans-deseret-fonts \
 google-noto-sans-devanagari-fonts \
 google-noto-sans-devanagari-ui-fonts \
 google-noto-sans-devanagari-vf-fonts \
 google-noto-sans-duployan-fonts \
 google-noto-sans-egyptian-hieroglyphs-fonts \
 google-noto-sans-elbasan-fonts \
 google-noto-sans-elymaic-fonts \
 google-noto-sans-ethiopic-fonts \
 google-noto-sans-ethiopic-vf-fonts \
 google-noto-sans-fonts \
 google-noto-sans-georgian-fonts \
 google-noto-sans-georgian-vf-fonts \
 google-noto-sans-glagolitic-fonts \
 google-noto-sans-gothic-fonts \
 google-noto-sans-grantha-fonts \
 google-noto-sans-gujarati-fonts \
 google-noto-sans-gujarati-ui-fonts \
 google-noto-sans-gujarati-vf-fonts \
 google-noto-sans-gunjala-gondi-fonts \
 google-noto-sans-gunjala-gondi-vf-fonts \
 google-noto-sans-gurmukhi-fonts \
 google-noto-sans-gurmukhi-ui-fonts \
 google-noto-sans-gurmukhi-vf-fonts \
 google-noto-sans-hanifi-rohingya-fonts \
 google-noto-sans-hanifi-rohingya-vf-fonts \
 google-noto-sans-hanunoo-fonts \
 google-noto-sans-hatran-fonts \
 google-noto-sans-hebrew-fonts \
 google-noto-sans-hebrew-vf-fonts \
 google-noto-sans-imperial-aramaic-fonts \
 google-noto-sans-indic-siyaq-numbers-fonts \
 google-noto-sans-inscriptional-pahlavi-fonts \
 google-noto-sans-inscriptional-parthian-fonts \
 google-noto-sans-javanese-fonts \
 google-noto-sans-javanese-vf-fonts \
 google-noto-sans-kaithi-fonts \
 google-noto-sans-kannada-fonts \
 google-noto-sans-kannada-ui-fonts \
 google-noto-sans-kannada-ui-vf-fonts \
 google-noto-sans-kannada-vf-fonts \
 google-noto-sans-kawi-fonts \
 google-noto-sans-kawi-vf-fonts \
 google-noto-sans-kayah-li-fonts \
 google-noto-sans-kayah-li-vf-fonts \
 google-noto-sans-kharoshthi-fonts \
 google-noto-sans-khmer-fonts \
 google-noto-sans-khmer-vf-fonts \
 google-noto-sans-khojki-fonts \
"

URI_google-noto-kufi-arabic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-kufi-arabic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-kufi-arabic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-kufi-arabic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-kufi-arabic-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-kufi-arabic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-music-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-music-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-music-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-naskh-arabic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-naskh-arabic-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-ui-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-naskh-arabic-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-naskh-arabic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-nastaliq-urdu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-nastaliq-urdu-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-nastaliq-urdu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-nastaliq-urdu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-nastaliq-urdu-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-nastaliq-urdu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-rashi-hebrew-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-rashi-hebrew-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-rashi-hebrew-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-rashi-hebrew-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-rashi-hebrew-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-rashi-hebrew-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-adlam-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-unjoined-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-unjoined-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-adlam-unjoined-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-unjoined-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-unjoined-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-adlam-unjoined-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-adlam-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-anatolian-hieroglyphs-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-anatolian-hieroglyphs-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-anatolian-hieroglyphs-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-arabic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-arabic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-arabic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-arabic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-arabic-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-arabic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-armenian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-armenian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-armenian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-armenian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-armenian-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-armenian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-avestan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-avestan-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-avestan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-balinese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-balinese-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-balinese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-balinese-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-balinese-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-balinese-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bamum-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bamum-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bamum-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bamum-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bamum-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bamum-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bassa-vah-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bassa-vah-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bassa-vah-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bassa-vah-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bassa-vah-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bassa-vah-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-batak-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-batak-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-batak-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bengali-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bengali-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bengali-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bengali-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bengali-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bengali-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bengali-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bengali-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bengali-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bhaiksuki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bhaiksuki-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-bhaiksuki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-brahmi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-brahmi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-brahmi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-buginese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-buginese-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-buginese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-buhid-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-buhid-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-buhid-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-canadian-aboriginal-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-canadian-aboriginal-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-canadian-aboriginal-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-canadian-aboriginal-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-canadian-aboriginal-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-canadian-aboriginal-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-carian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-carian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-carian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-caucasian-albanian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-caucasian-albanian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-caucasian-albanian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-chakma-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-chakma-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-chakma-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cham-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-cham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cham-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cham-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-cham-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cherokee-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cherokee-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-cherokee-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cherokee-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cherokee-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-cherokee-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-chorasmian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-chorasmian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-chorasmian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-coptic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-coptic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-coptic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cuneiform-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cuneiform-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-cuneiform-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cypriot-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cypriot-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-cypriot-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cypro-minoan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cypro-minoan-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-cypro-minoan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-deseret-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-deseret-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-deseret-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-devanagari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-devanagari-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-devanagari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-devanagari-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-devanagari-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-devanagari-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-devanagari-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-devanagari-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-devanagari-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-duployan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-duployan-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-duployan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-egyptian-hieroglyphs-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-egyptian-hieroglyphs-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-egyptian-hieroglyphs-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-elbasan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-elbasan-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-elbasan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-elymaic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-elymaic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-elymaic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ethiopic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ethiopic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-ethiopic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ethiopic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ethiopic-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-ethiopic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-georgian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-georgian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-georgian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-georgian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-georgian-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-georgian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-glagolitic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-glagolitic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-glagolitic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gothic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gothic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gothic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-grantha-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-grantha-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-grantha-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gujarati-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gujarati-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gujarati-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gujarati-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gujarati-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gujarati-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gujarati-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gujarati-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gujarati-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gunjala-gondi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gunjala-gondi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gunjala-gondi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gunjala-gondi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gunjala-gondi-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gunjala-gondi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gurmukhi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gurmukhi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gurmukhi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gurmukhi-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gurmukhi-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gurmukhi-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gurmukhi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gurmukhi-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-gurmukhi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hanifi-rohingya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hanifi-rohingya-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-hanifi-rohingya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hanifi-rohingya-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hanifi-rohingya-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-hanifi-rohingya-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hanunoo-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hanunoo-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-hanunoo-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hatran-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hatran-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-hatran-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hebrew-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hebrew-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-hebrew-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hebrew-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hebrew-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-hebrew-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-imperial-aramaic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-imperial-aramaic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-imperial-aramaic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-indic-siyaq-numbers-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-indic-siyaq-numbers-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-indic-siyaq-numbers-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-inscriptional-pahlavi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-inscriptional-pahlavi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-inscriptional-pahlavi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-inscriptional-parthian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-inscriptional-parthian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-inscriptional-parthian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-javanese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-javanese-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-javanese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-javanese-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-javanese-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-javanese-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kaithi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kaithi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kaithi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kannada-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kannada-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-ui-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kannada-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kannada-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kawi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kawi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kawi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kawi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kawi-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kawi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kayah-li-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kayah-li-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kayah-li-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kayah-li-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kayah-li-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kayah-li-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kharoshthi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kharoshthi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-kharoshthi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khmer-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khmer-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-khmer-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khmer-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khmer-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-khmer-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khojki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khojki-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-khojki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khudawadi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khudawadi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-khudawadi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lao-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-looped-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-looped-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lao-looped-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-looped-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-looped-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lao-looped-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lao-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lepcha-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lepcha-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lepcha-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-limbu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-limbu-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-limbu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-linear-a-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-linear-a-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-linear-a-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-linear-b-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-linear-b-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-linear-b-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lisu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lisu-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lisu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lisu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lisu-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lisu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lycian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lycian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lycian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lydian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lydian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-lydian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mahajani-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mahajani-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mahajani-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-malayalam-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-malayalam-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-ui-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-malayalam-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-malayalam-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mandaic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mandaic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mandaic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-manichaean-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-manichaean-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-manichaean-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-marchen-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-marchen-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-marchen-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-masaram-gondi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-masaram-gondi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-masaram-gondi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-math-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-math-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-math-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mayan-numerals-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mayan-numerals-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mayan-numerals-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-medefaidrin-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-medefaidrin-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-medefaidrin-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-medefaidrin-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-medefaidrin-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-medefaidrin-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-meetei-mayek-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-meetei-mayek-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-meetei-mayek-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-meetei-mayek-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-meetei-mayek-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-meetei-mayek-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mende-kikakui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mende-kikakui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mende-kikakui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-meroitic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-meroitic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-meroitic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-miao-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-miao-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-miao-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-modi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-modi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-modi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mongolian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mongolian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mongolian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mono-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mono-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mono-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mro-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mro-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-mro-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-multani-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-multani-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-multani-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-myanmar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-myanmar-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-myanmar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-myanmar-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-myanmar-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-myanmar-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nabataean-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nabataean-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nabataean-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nag-mundari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nag-mundari-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nag-mundari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nag-mundari-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nag-mundari-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nag-mundari-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nandinagari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nandinagari-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nandinagari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-new-tai-lue-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-new-tai-lue-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-new-tai-lue-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-new-tai-lue-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-new-tai-lue-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-new-tai-lue-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-newa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-newa-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-newa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nko-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nko-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nko-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nko-unjoined-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nko-unjoined-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nko-unjoined-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nko-unjoined-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nko-unjoined-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nko-unjoined-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nushu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nushu-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-nushu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ogham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ogham-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-ogham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ol-chiki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ol-chiki-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-ol-chiki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ol-chiki-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ol-chiki-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-ol-chiki-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-hungarian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-hungarian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-hungarian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-italic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-italic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-italic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-north-arabian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-north-arabian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-north-arabian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-permic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-permic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-permic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-persian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-persian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-persian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-sogdian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-sogdian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-sogdian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-south-arabian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-south-arabian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-south-arabian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-turkic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-turkic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-old-turkic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-oriya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-oriya-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-oriya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-oriya-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-oriya-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-oriya-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-osage-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-osage-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-osage-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-osmanya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-osmanya-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-osmanya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-pahawh-hmong-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-pahawh-hmong-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-pahawh-hmong-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-palmyrene-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-palmyrene-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-palmyrene-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-pau-cin-hau-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-pau-cin-hau-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-pau-cin-hau-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-phagspa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-phagspa-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-phagspa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-phoenician-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-phoenician-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-phoenician-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-psalter-pahlavi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-psalter-pahlavi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-psalter-pahlavi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-rejang-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-rejang-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-rejang-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-runic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-runic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-runic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-samaritan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-samaritan-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-samaritan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-saurashtra-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-saurashtra-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-saurashtra-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sharada-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sharada-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sharada-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-shavian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-shavian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-shavian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-siddham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-siddham-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-siddham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-signwriting-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-signwriting-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-signwriting-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sinhala-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sinhala-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sinhala-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sinhala-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sinhala-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sinhala-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sinhala-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sinhala-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sinhala-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sogdian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sogdian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sogdian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sora-sompeng-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sora-sompeng-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sora-sompeng-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sora-sompeng-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sora-sompeng-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sora-sompeng-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-soyombo-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-soyombo-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-soyombo-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sundanese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sundanese-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sundanese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sundanese-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sundanese-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-sundanese-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syloti-nagri-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syloti-nagri-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-syloti-nagri-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-symbols-2-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-symbols-2-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-symbols-2-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-symbols-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-symbols-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-symbols-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-symbols-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-symbols-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-symbols-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-eastern-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-eastern-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-syriac-eastern-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-eastern-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-eastern-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-syriac-eastern-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-syriac-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-syriac-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-western-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-western-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-syriac-western-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-western-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-western-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-syriac-western-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tagalog-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tagalog-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tagalog-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tagbanwa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tagbanwa-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tagbanwa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-le-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-le-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tai-le-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-tham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-tham-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tai-tham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-tham-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-tham-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tai-tham-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-viet-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-viet-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tai-viet-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-takri-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-takri-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-takri-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tamil-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-supplement-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-supplement-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tamil-supplement-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tamil-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-ui-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tamil-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tamil-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tangsa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tangsa-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tangsa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tangsa-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tangsa-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tangsa-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-telugu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-ui-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-telugu-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-ui-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-telugu-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-telugu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thaana-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thaana-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-thaana-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thaana-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thaana-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-thaana-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thai-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thai-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-thai-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thai-looped-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thai-looped-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-thai-looped-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thai-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thai-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-thai-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-adrar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-adrar-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-adrar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-agraw-imazighen-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-agraw-imazighen-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-agraw-imazighen-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-ahaggar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-ahaggar-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-ahaggar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-air-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-air-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-air-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-apt-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-apt-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-apt-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-azawagh-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-azawagh-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-azawagh-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-ghat-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-ghat-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-ghat-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-hawad-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-hawad-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-hawad-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-rhissa-ixa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-rhissa-ixa-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-rhissa-ixa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-sil-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-sil-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-sil-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-tawellemmet-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-tawellemmet-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tifinagh-tawellemmet-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tirhuta-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tirhuta-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-tirhuta-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ugaritic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ugaritic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-ugaritic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vai-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-vai-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-vai-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vithkuqi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-vithkuqi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-vithkuqi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vithkuqi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-vithkuqi-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-vithkuqi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-wancho-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-wancho-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-wancho-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-warang-citi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-warang-citi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-warang-citi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-yi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-yi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-yi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-zanabazar-square-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-zanabazar-square-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-sans-zanabazar-square-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ahom-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ahom-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-ahom-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-armenian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-armenian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-armenian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-armenian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-armenian-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-armenian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-balinese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-balinese-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-balinese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-bengali-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-bengali-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-bengali-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-bengali-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-bengali-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-bengali-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-devanagari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-devanagari-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-devanagari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-devanagari-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-devanagari-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-devanagari-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-dives-akuru-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-dives-akuru-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-dives-akuru-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-dogra-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-dogra-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-dogra-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ethiopic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ethiopic-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-ethiopic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ethiopic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ethiopic-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-ethiopic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-georgian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-georgian-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-georgian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-georgian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-georgian-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-georgian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-grantha-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-grantha-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-grantha-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gujarati-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gujarati-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-gujarati-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gujarati-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gujarati-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-gujarati-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gurmukhi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gurmukhi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-gurmukhi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gurmukhi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gurmukhi-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-gurmukhi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-hebrew-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-hebrew-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-hebrew-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-hebrew-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-hebrew-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-hebrew-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-kannada-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-kannada-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-kannada-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-kannada-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-kannada-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-kannada-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khitan-small-script-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khitan-small-script-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-khitan-small-script-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khmer-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khmer-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-khmer-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khmer-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khmer-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-khmer-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khojki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khojki-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-khojki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khojki-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khojki-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-khojki-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-lao-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-lao-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-lao-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-lao-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-lao-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-lao-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-makasar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-makasar-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-makasar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-malayalam-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-malayalam-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-malayalam-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-malayalam-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-malayalam-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-malayalam-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-myanmar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-myanmar-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-myanmar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-np-hmong-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-np-hmong-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-np-hmong-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-np-hmong-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-np-hmong-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-np-hmong-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-old-uyghur-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-old-uyghur-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-old-uyghur-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-oriya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-oriya-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-oriya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-oriya-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-oriya-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-oriya-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ottoman-siyaq-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ottoman-siyaq-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-ottoman-siyaq-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-sinhala-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-sinhala-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-sinhala-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-sinhala-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-sinhala-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-sinhala-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tamil-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tamil-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-tamil-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tamil-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tamil-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-tamil-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tangut-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tangut-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-tangut-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-telugu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-telugu-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-telugu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-telugu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-telugu-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-telugu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-thai-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-thai-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-thai-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-thai-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-thai-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-thai-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tibetan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tibetan-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-tibetan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tibetan-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tibetan-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-tibetan-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-toto-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-toto-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-toto-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-toto-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-toto-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-toto-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-vithkuqi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-vithkuqi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-vithkuqi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-vithkuqi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-vithkuqi-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-vithkuqi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-yezidi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-yezidi-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-yezidi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-yezidi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-yezidi-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-yezidi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-traditional-nushu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-traditional-nushu-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-traditional-nushu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-traditional-nushu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-traditional-nushu-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-traditional-nushu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fonts-all-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/google-noto-fonts-all-static-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-fonts-all-static = " \
 google-noto-sans-khudawadi-fonts \
 google-noto-sans-lao-fonts \
 google-noto-sans-lao-looped-fonts \
 google-noto-sans-lepcha-fonts \
 google-noto-sans-limbu-fonts \
 google-noto-sans-linear-a-fonts \
 google-noto-sans-linear-b-fonts \
 google-noto-sans-lisu-fonts \
 google-noto-sans-lycian-fonts \
 google-noto-sans-lydian-fonts \
 google-noto-sans-mahajani-fonts \
 google-noto-sans-malayalam-fonts \
 google-noto-sans-malayalam-ui-fonts \
 google-noto-sans-mandaic-fonts \
 google-noto-sans-manichaean-fonts \
 google-noto-sans-marchen-fonts \
 google-noto-sans-masaram-gondi-fonts \
 google-noto-sans-math-fonts \
 google-noto-sans-mayan-numerals-fonts \
 google-noto-sans-medefaidrin-fonts \
 google-noto-sans-meetei-mayek-fonts \
 google-noto-sans-mende-kikakui-fonts \
 google-noto-sans-meroitic-fonts \
 google-noto-sans-miao-fonts \
 google-noto-sans-modi-fonts \
 google-noto-sans-mongolian-fonts \
 google-noto-sans-mono-fonts \
 google-noto-sans-mro-fonts \
 google-noto-sans-multani-fonts \
 google-noto-sans-myanmar-fonts \
 google-noto-sans-nabataean-fonts \
 google-noto-sans-nag-mundari-fonts \
 google-noto-sans-nandinagari-fonts \
 google-noto-sans-new-tai-lue-fonts \
 google-noto-sans-newa-fonts \
 google-noto-sans-nko-fonts \
 google-noto-sans-nko-unjoined-fonts \
 google-noto-sans-nushu-fonts \
 google-noto-sans-ogham-fonts \
 google-noto-sans-ol-chiki-fonts \
 google-noto-sans-old-hungarian-fonts \
 google-noto-sans-old-italic-fonts \
 google-noto-sans-old-north-arabian-fonts \
 google-noto-sans-old-permic-fonts \
 google-noto-sans-old-persian-fonts \
 google-noto-sans-old-sogdian-fonts \
 google-noto-sans-old-south-arabian-fonts \
 google-noto-sans-old-turkic-fonts \
 google-noto-sans-oriya-fonts \
 google-noto-sans-osage-fonts \
 google-noto-sans-osmanya-fonts \
 google-noto-sans-pahawh-hmong-fonts \
 google-noto-sans-palmyrene-fonts \
 google-noto-sans-pau-cin-hau-fonts \
 google-noto-sans-phagspa-fonts \
 google-noto-sans-phoenician-fonts \
 google-noto-sans-psalter-pahlavi-fonts \
 google-noto-sans-rejang-fonts \
 google-noto-sans-runic-fonts \
 google-noto-sans-samaritan-fonts \
 google-noto-sans-saurashtra-fonts \
 google-noto-sans-sharada-fonts \
 google-noto-sans-shavian-fonts \
 google-noto-sans-siddham-fonts \
 google-noto-sans-signwriting-fonts \
 google-noto-sans-sinhala-fonts \
 google-noto-sans-sinhala-ui-fonts \
 google-noto-sans-sogdian-fonts \
 google-noto-sans-sora-sompeng-fonts \
 google-noto-sans-soyombo-fonts \
 google-noto-sans-sundanese-fonts \
 google-noto-sans-syloti-nagri-fonts \
 google-noto-sans-symbols-2-fonts \
 google-noto-sans-symbols-fonts \
 google-noto-sans-syriac-eastern-fonts \
 google-noto-sans-syriac-fonts \
 google-noto-sans-syriac-western-fonts \
 google-noto-sans-tagalog-fonts \
 google-noto-sans-tagbanwa-fonts \
 google-noto-sans-tai-le-fonts \
 google-noto-sans-tai-tham-fonts \
 google-noto-sans-tai-viet-fonts \
 google-noto-sans-takri-fonts \
 google-noto-sans-tamil-fonts \
 google-noto-sans-tamil-supplement-fonts \
 google-noto-sans-tamil-ui-fonts \
 google-noto-sans-tangsa-fonts \
 google-noto-sans-telugu-fonts \
 google-noto-sans-telugu-ui-fonts \
 google-noto-sans-thaana-fonts \
 google-noto-sans-thai-fonts \
 google-noto-sans-thai-looped-fonts \
 google-noto-sans-tifinagh-adrar-fonts \
 google-noto-sans-tifinagh-agraw-imazighen-fonts \
 google-noto-sans-tifinagh-ahaggar-fonts \
 google-noto-sans-tifinagh-air-fonts \
 google-noto-sans-tifinagh-apt-fonts \
 google-noto-sans-tifinagh-azawagh-fonts \
 google-noto-sans-tifinagh-fonts \
 google-noto-sans-tifinagh-ghat-fonts \
 google-noto-sans-tifinagh-hawad-fonts \
 google-noto-sans-tifinagh-rhissa-ixa-fonts \
 google-noto-sans-tifinagh-sil-fonts \
 google-noto-sans-tifinagh-tawellemmet-fonts \
 google-noto-sans-tirhuta-fonts \
 google-noto-sans-ugaritic-fonts \
 google-noto-sans-vai-fonts \
 google-noto-sans-vithkuqi-fonts \
 google-noto-sans-wancho-fonts \
 google-noto-sans-warang-citi-fonts \
 google-noto-sans-yi-fonts \
 google-noto-sans-zanabazar-square-fonts \
 google-noto-serif-ahom-fonts \
 google-noto-serif-armenian-fonts \
 google-noto-serif-balinese-fonts \
 google-noto-serif-bengali-fonts \
 google-noto-serif-devanagari-fonts \
 google-noto-serif-dives-akuru-fonts \
 google-noto-serif-dogra-fonts \
 google-noto-serif-ethiopic-fonts \
 google-noto-serif-fonts \
 google-noto-serif-georgian-fonts \
 google-noto-serif-grantha-fonts \
 google-noto-serif-gujarati-fonts \
 google-noto-serif-gurmukhi-fonts \
 google-noto-serif-hebrew-fonts \
 google-noto-serif-kannada-fonts \
 google-noto-serif-khitan-small-script-fonts \
 google-noto-serif-khmer-fonts \
 google-noto-serif-khojki-fonts \
 google-noto-serif-lao-fonts \
 google-noto-serif-makasar-fonts \
 google-noto-serif-malayalam-fonts \
 google-noto-serif-myanmar-fonts \
 google-noto-serif-np-hmong-fonts \
 google-noto-serif-old-uyghur-fonts \
 google-noto-serif-oriya-fonts \
 google-noto-serif-ottoman-siyaq-fonts \
 google-noto-serif-sinhala-fonts \
 google-noto-serif-tamil-fonts \
 google-noto-serif-tangut-fonts \
 google-noto-serif-telugu-fonts \
 google-noto-serif-thai-fonts \
 google-noto-serif-tibetan-fonts \
 google-noto-serif-toto-fonts \
 google-noto-serif-vithkuqi-fonts \
 google-noto-serif-yezidi-fonts \
 google-noto-traditional-nushu-fonts \
 google-noto-fangsong-kss-rotated-fonts \
 google-noto-fangsong-kss-vertical-fonts \
 google-noto-kufi-arabic-fonts \
 google-noto-music-fonts \
 google-noto-naskh-arabic-fonts \
 google-noto-naskh-arabic-ui-fonts \
 google-noto-nastaliq-urdu-fonts \
 google-noto-rashi-hebrew-fonts \
 google-noto-sans-adlam-fonts \
 google-noto-sans-adlam-unjoined-fonts \
 google-noto-sans-anatolian-hieroglyphs-fonts \
 google-noto-sans-arabic-fonts \
 google-noto-sans-armenian-fonts \
 google-noto-sans-avestan-fonts \
 google-noto-sans-balinese-fonts \
 google-noto-sans-bamum-fonts \
 google-noto-sans-bassa-vah-fonts \
 google-noto-sans-batak-fonts \
 google-noto-sans-bengali-fonts \
 google-noto-sans-bengali-ui-fonts \
 google-noto-sans-bhaiksuki-fonts \
 google-noto-sans-brahmi-fonts \
 google-noto-sans-buginese-fonts \
 google-noto-sans-buhid-fonts \
 google-noto-sans-canadian-aboriginal-fonts \
 google-noto-sans-carian-fonts \
 google-noto-sans-caucasian-albanian-fonts \
 google-noto-sans-chakma-fonts \
 google-noto-sans-cham-fonts \
 google-noto-sans-cherokee-fonts \
 google-noto-sans-chorasmian-fonts \
 google-noto-sans-coptic-fonts \
 google-noto-sans-cuneiform-fonts \
 google-noto-sans-cypriot-fonts \
 google-noto-sans-cypro-minoan-fonts \
 google-noto-sans-deseret-fonts \
 google-noto-sans-devanagari-fonts \
 google-noto-sans-devanagari-ui-fonts \
 google-noto-sans-duployan-fonts \
 google-noto-sans-egyptian-hieroglyphs-fonts \
 google-noto-sans-elbasan-fonts \
 google-noto-sans-elymaic-fonts \
 google-noto-sans-ethiopic-fonts \
 google-noto-sans-fonts \
 google-noto-sans-georgian-fonts \
 google-noto-sans-glagolitic-fonts \
 google-noto-sans-gothic-fonts \
 google-noto-sans-grantha-fonts \
 google-noto-sans-gujarati-fonts \
 google-noto-sans-gujarati-ui-fonts \
 google-noto-sans-gunjala-gondi-fonts \
 google-noto-sans-gurmukhi-fonts \
 google-noto-sans-gurmukhi-ui-fonts \
 google-noto-sans-hanifi-rohingya-fonts \
 google-noto-sans-hanunoo-fonts \
 google-noto-sans-hatran-fonts \
 google-noto-sans-hebrew-fonts \
 google-noto-sans-imperial-aramaic-fonts \
 google-noto-sans-indic-siyaq-numbers-fonts \
 google-noto-sans-inscriptional-pahlavi-fonts \
 google-noto-sans-inscriptional-parthian-fonts \
 google-noto-sans-javanese-fonts \
 google-noto-sans-kaithi-fonts \
 google-noto-sans-kannada-fonts \
 google-noto-sans-kannada-ui-fonts \
 google-noto-sans-kawi-fonts \
 google-noto-sans-kayah-li-fonts \
 google-noto-sans-kharoshthi-fonts \
 google-noto-sans-khmer-fonts \
 google-noto-sans-khojki-fonts \
"

URI_google-noto-fonts-all-vf = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/google-noto-fonts-all-vf-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-fonts-all-vf = " \
 google-noto-sans-lao-looped-vf-fonts \
 google-noto-sans-lao-vf-fonts \
 google-noto-sans-lisu-vf-fonts \
 google-noto-sans-malayalam-ui-vf-fonts \
 google-noto-sans-malayalam-vf-fonts \
 google-noto-sans-medefaidrin-vf-fonts \
 google-noto-sans-meetei-mayek-vf-fonts \
 google-noto-sans-myanmar-vf-fonts \
 google-noto-sans-nag-mundari-vf-fonts \
 google-noto-sans-new-tai-lue-vf-fonts \
 google-noto-sans-nko-unjoined-vf-fonts \
 google-noto-sans-ol-chiki-vf-fonts \
 google-noto-sans-oriya-vf-fonts \
 google-noto-sans-mono-vf-fonts \
 google-noto-sans-vf-fonts \
 google-noto-serif-vf-fonts \
 google-noto-sans-sinhala-vf-fonts \
 google-noto-sans-sora-sompeng-vf-fonts \
 google-noto-sans-sundanese-vf-fonts \
 google-noto-sans-symbols-vf-fonts \
 google-noto-sans-syriac-eastern-vf-fonts \
 google-noto-sans-syriac-vf-fonts \
 google-noto-sans-syriac-western-vf-fonts \
 google-noto-sans-tai-tham-vf-fonts \
 google-noto-sans-tamil-ui-vf-fonts \
 google-noto-sans-tamil-vf-fonts \
 google-noto-sans-tangsa-vf-fonts \
 google-noto-sans-telugu-ui-vf-fonts \
 google-noto-sans-telugu-vf-fonts \
 google-noto-sans-thaana-vf-fonts \
 google-noto-sans-thai-vf-fonts \
 google-noto-sans-vithkuqi-vf-fonts \
 google-noto-serif-armenian-vf-fonts \
 google-noto-serif-bengali-vf-fonts \
 google-noto-serif-devanagari-vf-fonts \
 google-noto-serif-ethiopic-vf-fonts \
 google-noto-serif-georgian-vf-fonts \
 google-noto-serif-gujarati-vf-fonts \
 google-noto-serif-gurmukhi-vf-fonts \
 google-noto-serif-hebrew-vf-fonts \
 google-noto-serif-kannada-vf-fonts \
 google-noto-serif-khmer-vf-fonts \
 google-noto-serif-khojki-vf-fonts \
 google-noto-serif-lao-vf-fonts \
 google-noto-serif-malayalam-vf-fonts \
 google-noto-serif-np-hmong-vf-fonts \
 google-noto-serif-oriya-vf-fonts \
 google-noto-serif-sinhala-vf-fonts \
 google-noto-serif-tamil-vf-fonts \
 google-noto-serif-telugu-vf-fonts \
 google-noto-serif-thai-vf-fonts \
 google-noto-serif-tibetan-vf-fonts \
 google-noto-serif-toto-vf-fonts \
 google-noto-serif-vithkuqi-vf-fonts \
 google-noto-serif-yezidi-vf-fonts \
 google-noto-traditional-nushu-vf-fonts \
 google-noto-kufi-arabic-vf-fonts \
 google-noto-naskh-arabic-ui-vf-fonts \
 google-noto-naskh-arabic-vf-fonts \
 google-noto-nastaliq-urdu-vf-fonts \
 google-noto-rashi-hebrew-vf-fonts \
 google-noto-sans-adlam-unjoined-vf-fonts \
 google-noto-sans-adlam-vf-fonts \
 google-noto-sans-arabic-vf-fonts \
 google-noto-sans-armenian-vf-fonts \
 google-noto-sans-balinese-vf-fonts \
 google-noto-sans-bamum-vf-fonts \
 google-noto-sans-bassa-vah-vf-fonts \
 google-noto-sans-bengali-vf-fonts \
 google-noto-sans-canadian-aboriginal-vf-fonts \
 google-noto-sans-cham-vf-fonts \
 google-noto-sans-cherokee-vf-fonts \
 google-noto-sans-devanagari-vf-fonts \
 google-noto-sans-ethiopic-vf-fonts \
 google-noto-sans-georgian-vf-fonts \
 google-noto-sans-gujarati-vf-fonts \
 google-noto-sans-gunjala-gondi-vf-fonts \
 google-noto-sans-gurmukhi-vf-fonts \
 google-noto-sans-hanifi-rohingya-vf-fonts \
 google-noto-sans-hebrew-vf-fonts \
 google-noto-sans-javanese-vf-fonts \
 google-noto-sans-kannada-ui-vf-fonts \
 google-noto-sans-kannada-vf-fonts \
 google-noto-sans-kawi-vf-fonts \
 google-noto-sans-kayah-li-vf-fonts \
 google-noto-sans-khmer-vf-fonts \
"

URI_google-noto-serif-myanmar-vf-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/google-noto-serif-myanmar-vf-fonts-20240401-5.el10.noarch.rpm;unpack=0"
RDEPENDS:google-noto-serif-myanmar-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"
