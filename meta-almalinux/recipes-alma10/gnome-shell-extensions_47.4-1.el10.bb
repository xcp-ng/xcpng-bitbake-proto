
PN = "gnome-shell-extensions"
PE = "0"
PV = "47.4"
PR = "1.el10"
PACKAGES = "gnome-classic-session gnome-shell-extension-apps-menu gnome-shell-extension-auto-move-windows gnome-shell-extension-classification-banner gnome-shell-extension-common gnome-shell-extension-custom-menu gnome-shell-extension-desktop-icons gnome-shell-extension-drive-menu gnome-shell-extension-gesture-inhibitor gnome-shell-extension-heads-up-display gnome-shell-extension-launch-new-instance gnome-shell-extension-light-style gnome-shell-extension-native-window-placement gnome-shell-extension-places-menu gnome-shell-extension-screenshot-window-sizer gnome-shell-extension-status-icons gnome-shell-extension-system-monitor gnome-shell-extension-user-theme gnome-shell-extension-window-list gnome-shell-extension-windowsNavigator gnome-shell-extension-workspace-indicator"


URI_gnome-classic-session = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-classic-session-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-classic-session = "nautilus ( ) gnome-shell-extension-apps-menu ( =  47.4-1.el10) gnome-shell-extension-launch-new-instance ( =  47.4-1.el10) gnome-shell-extension-places-menu ( =  47.4-1.el10) gnome-shell-extension-window-list ( =  47.4-1.el10)"
RPROVIDES:gnome-classic-session = "gnome-classic-session ( =  47.4-1.el10)"

URI_gnome-shell-extension-apps-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-apps-menu-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-apps-menu = "gnome-menus ( ) gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-apps-menu = "gnome-shell-extension-apps-menu ( =  47.4-1.el10)"

URI_gnome-shell-extension-auto-move-windows = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-auto-move-windows-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-auto-move-windows = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-auto-move-windows = "gnome-shell-extension-auto-move-windows ( =  47.4-1.el10)"

URI_gnome-shell-extension-classification-banner = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-classification-banner-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-classification-banner = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-classification-banner = "gnome-shell-extension-classification-banner ( =  47.4-1.el10)"

URI_gnome-shell-extension-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-common-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-common = "gnome-shell ( >=  47)"
RPROVIDES:gnome-shell-extension-common = "gnome-shell-extension-common ( =  47.4-1.el10)"

URI_gnome-shell-extension-custom-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-custom-menu-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-custom-menu = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-custom-menu = "gnome-shell-extension-custom-menu ( =  47.4-1.el10)"

URI_gnome-shell-extension-desktop-icons = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-desktop-icons-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-desktop-icons = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-desktop-icons = "gnome-shell-extension-desktop-icons ( =  47.4-1.el10)"

URI_gnome-shell-extension-drive-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-drive-menu-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-drive-menu = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-drive-menu = "gnome-shell-extension-drive-menu ( =  47.4-1.el10)"

URI_gnome-shell-extension-gesture-inhibitor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-gesture-inhibitor-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-gesture-inhibitor = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-gesture-inhibitor = "gnome-shell-extension-gesture-inhibitor ( =  47.4-1.el10)"

URI_gnome-shell-extension-heads-up-display = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-heads-up-display-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-heads-up-display = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-heads-up-display = "gnome-shell-extension-heads-up-display ( =  47.4-1.el10)"

URI_gnome-shell-extension-launch-new-instance = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-launch-new-instance-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-launch-new-instance = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-launch-new-instance = "gnome-shell-extension-launch-new-instance ( =  47.4-1.el10)"

URI_gnome-shell-extension-light-style = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-light-style-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-light-style = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-light-style = "gnome-shell-extension-light-style ( =  47.4-1.el10)"

URI_gnome-shell-extension-native-window-placement = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-native-window-placement-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-native-window-placement = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-native-window-placement = "gnome-shell-extension-native-window-placement ( =  47.4-1.el10)"

URI_gnome-shell-extension-places-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-places-menu-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-places-menu = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-places-menu = "gnome-shell-extension-places-menu ( =  47.4-1.el10)"

URI_gnome-shell-extension-screenshot-window-sizer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-screenshot-window-sizer-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-screenshot-window-sizer = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-screenshot-window-sizer = "gnome-shell-extension-screenshot-window-sizer ( =  47.4-1.el10)"

URI_gnome-shell-extension-status-icons = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-status-icons-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-status-icons = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-status-icons = "gnome-shell-extension-status-icons ( =  47.4-1.el10) gnome-shell-extension-top-icons ( =  47.4-1.el10)"

URI_gnome-shell-extension-system-monitor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-system-monitor-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-system-monitor = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-system-monitor = "gnome-shell-extension-system-monitor ( =  47.4-1.el10)"

URI_gnome-shell-extension-user-theme = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-user-theme-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-user-theme = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-user-theme = "gnome-shell-extension-user-theme ( =  47.4-1.el10)"

URI_gnome-shell-extension-window-list = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-window-list-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-window-list = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-window-list = "gnome-shell-extension-window-list ( =  47.4-1.el10)"

URI_gnome-shell-extension-windowsNavigator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-windowsNavigator-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-windowsNavigator = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-windowsNavigator = "gnome-shell-extension-windowsNavigator ( =  47.4-1.el10)"

URI_gnome-shell-extension-workspace-indicator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-workspace-indicator-47.4-1.el10.noarch.rpm;unpack=0"
RDEPENDS:gnome-shell-extension-workspace-indicator = "gnome-shell-extension-common ( =  47.4-1.el10)"
RPROVIDES:gnome-shell-extension-workspace-indicator = "gnome-shell-extension-workspace-indicator ( =  47.4-1.el10)"
