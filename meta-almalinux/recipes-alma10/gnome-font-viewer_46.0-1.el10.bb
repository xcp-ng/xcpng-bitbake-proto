
PN = "gnome-font-viewer"
PE = "0"
PV = "46.0"
PR = "1.el10"
PACKAGES = "gnome-font-viewer"


URI_gnome-font-viewer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-font-viewer-46.0-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:gnome-font-viewer = "rtld(GNU_HASH) ( ) libm.so.6()(64bit) ( ) libgcc_s.so.1()(64bit) ( ) libgcc_s.so.1(GCC_3.0)(64bit) ( ) libgcc_s.so.1(GCC_3.3.1)(64bit) ( ) libc.so.6(GLIBC_2.34)(64bit) ( ) libm.so.6(GLIBC_2.2.5)(64bit) ( ) libglib-2.0.so.0()(64bit) ( ) libgobject-2.0.so.0()(64bit) ( ) libgio-2.0.so.0()(64bit) ( ) libcairo.so.2()(64bit) ( ) libpango-1.0.so.0()(64bit) ( ) libpangocairo-1.0.so.0()(64bit) ( ) libfontconfig.so.1()(64bit) ( ) libfreetype.so.6()(64bit) ( ) libgtk-4.so.1()(64bit) ( ) libharfbuzz.so.0()(64bit) ( ) libadwaita-1.so.0()(64bit) ( ) libadwaita-1.so.0(LIBADWAITA_1_0)(64bit) ( ) libgraphene-1.0.so.0()(64bit) ( ) libfribidi.so.0()(64bit) ( )"
RPROVIDES:gnome-font-viewer = "metainfo() ( ) application() ( ) application(org.gnome.font-viewer.desktop) ( ) metainfo(org.gnome.font-viewer.appdata.xml) ( ) mimehandler(application/x-font-otf) ( ) mimehandler(application/x-font-pcf) ( ) mimehandler(application/x-font-ttf) ( ) mimehandler(application/x-font-type1) ( ) mimehandler(font/otf) ( ) mimehandler(font/ttf) ( ) mimehandler(font/woff) ( ) gnome-font-viewer ( =  46.0-1.el10) gnome-font-viewer(x86-64) ( =  46.0-1.el10)"
