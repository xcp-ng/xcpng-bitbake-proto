
inherit dnf-bridge

PN = "mozilla-filesystem"
PE = "0"
PV = "1.9"
PR = "35.el10"
PACKAGES = "mozilla-filesystem"


URI_mozilla-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mozilla-filesystem-1.9-35.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:mozilla-filesystem = ""
