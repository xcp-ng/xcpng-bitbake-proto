
PN = "gnome-desktop-testing"
PE = "0"
PV = "2018.1"
PR = "21.el10"
PACKAGES = "gnome-desktop-testing"


URI_gnome-desktop-testing = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-desktop-testing-2018.1-21.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:gnome-desktop-testing = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.34)(64bit) ( ) libgcc_s.so.1()(64bit) ( ) libgcc_s.so.1(GCC_3.0)(64bit) ( ) libgcc_s.so.1(GCC_3.3.1)(64bit) ( ) libglib-2.0.so.0()(64bit) ( ) libgobject-2.0.so.0()(64bit) ( ) libgio-2.0.so.0()(64bit) ( ) libsystemd.so.0()(64bit) ( ) libsystemd.so.0(LIBSYSTEMD_209)(64bit) ( )"
RPROVIDES:gnome-desktop-testing = "gnome-desktop-testing ( =  2018.1-21.el10) gnome-desktop-testing(x86-64) ( =  2018.1-21.el10)"
