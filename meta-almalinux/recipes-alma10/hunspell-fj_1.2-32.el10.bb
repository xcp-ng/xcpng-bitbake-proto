
PN = "hunspell-fj"
PE = "0"
PV = "1.2"
PR = "32.el10"
PACKAGES = "hunspell-fj"


URI_hunspell-fj = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-fj-1.2-32.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-fj = "
 hunspell-filesystem
"
