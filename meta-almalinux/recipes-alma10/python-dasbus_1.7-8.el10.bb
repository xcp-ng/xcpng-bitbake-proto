
PN = "python-dasbus"
PE = "0"
PV = "1.7"
PR = "8.el10"
PACKAGES = "python3-dasbus"


URI_python3-dasbus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-dasbus-1.7-8.el10.noarch.rpm;unpack=0"
RDEPENDS:python3-dasbus = "python3-gobject-base ( ) python(abi) ( =  3.12)"
RPROVIDES:python3-dasbus = "python-dasbus ( =  1.7-8.el10) python3-dasbus ( =  1.7-8.el10) python3.12-dasbus ( =  1.7-8.el10) python3.12dist(dasbus) ( =  1.7) python3dist(dasbus) ( =  1.7)"
