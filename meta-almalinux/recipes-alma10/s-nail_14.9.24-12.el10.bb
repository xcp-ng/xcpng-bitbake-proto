
PN = "s-nail"
PE = "0"
PV = "14.9.24"
PR = "12.el10"
PACKAGES = "s-nail"


URI_s-nail = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/s-nail-14.9.24-12.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:s-nail = "
 openssl-libs
 krb5-libs
 bash
 ncurses-libs
 glibc
 alternatives
 libidn2
"
