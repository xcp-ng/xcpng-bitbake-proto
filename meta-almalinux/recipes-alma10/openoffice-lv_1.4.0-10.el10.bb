
PN = "openoffice-lv"
PE = "0"
PV = "1.4.0"
PR = "10.el10"
PACKAGES = "hunspell-lv hyphen-lv"


URI_hunspell-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-lv-1.4.0-10.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-lv = "
 hunspell
"

URI_hyphen-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-lv-1.4.0-10.el10.noarch.rpm;unpack=0"
RDEPENDS:hyphen-lv = "
 hyphen
"
