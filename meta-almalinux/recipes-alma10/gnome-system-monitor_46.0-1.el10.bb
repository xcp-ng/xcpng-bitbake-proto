
PN = "gnome-system-monitor"
PE = "0"
PV = "46.0"
PR = "1.el10"
PACKAGES = "gnome-system-monitor"


URI_gnome-system-monitor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-system-monitor-46.0-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:gnome-system-monitor = " \
 gtkmm4.0 \
 systemd-libs \
 librsvg2 \
 libgcc \
 libsigc++30 \
 pango \
 gdk-pixbuf2 \
 glibmm2.68 \
 libstdc++ \
 glib2 \
 cairo \
 graphene \
 glibc \
 libgtop2 \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
"
