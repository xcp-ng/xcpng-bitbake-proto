
PN = "dmidecode"
PE = "1"
PV = "3.6"
PR = "3.el10"
PACKAGES = ""

