
PN = "c2esp"
PE = "0"
PV = "2.7"
PR = "34.el10"
PACKAGES = "c2esp"


URI_c2esp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/c2esp-2.7-34.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:c2esp = "
 zlib-ng-compat
 cups-filesystem
 cups-libs
 jbigkit-libs
 libcupsfilters
 glibc
 libppd
"
