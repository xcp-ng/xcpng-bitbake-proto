
PN = "open-sans-fonts"
PE = "0"
PV = "1.10"
PR = "24.el10"
PACKAGES = "open-sans-fonts"


URI_open-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/open-sans-fonts-1.10-24.el10.noarch.rpm;unpack=0"
RDEPENDS:open-sans-fonts = "fontpackages-filesystem ( )"
RPROVIDES:open-sans-fonts = "font(opensans) ( ) font(opensansextrabold) ( ) font(opensanslight) ( ) font(opensanssemibold) ( ) config(open-sans-fonts) ( =  1.10-24.el10) open-sans-fonts ( =  1.10-24.el10)"
