
PN = "catch1"
PE = "0"
PV = "1.12.2"
PR = "17.el10"
PACKAGES = "catch1-devel"


URI_catch1-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/catch1-devel-1.12.2-17.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:catch1-devel = ""
