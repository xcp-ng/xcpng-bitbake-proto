
PN = "hunspell-tet"
PE = "0"
PV = "0.20050108"
PR = "35.el10"
PACKAGES = "hunspell-tet"


URI_hunspell-tet = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-tet-0.20050108-35.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-tet = " \
 hunspell-filesystem \
"
