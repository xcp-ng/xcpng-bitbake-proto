
PN = "man-pages"
PE = "0"
PV = "6.06"
PR = "8.el10_0"
PACKAGES = "man-pages"


URI_man-pages = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/man-pages-6.06-8.el10_0.noarch.rpm;unpack=0"
RDEPENDS:man-pages = "/bin/sh ( ) /usr/sbin/update-alternatives ( )"
RPROVIDES:man-pages = "man-pages ( =  6.06-8.el10_0)"
