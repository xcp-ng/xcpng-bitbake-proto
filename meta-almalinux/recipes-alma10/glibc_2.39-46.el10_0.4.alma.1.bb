
PN = "glibc"
PE = "0"
PV = "2.39"
PR = "46.el10_0.4.alma.1"
PACKAGES = "glibc glibc-all-langpacks glibc-common glibc-gconv-extra glibc-langpack-aa glibc-langpack-af glibc-langpack-agr glibc-langpack-ak glibc-langpack-am glibc-langpack-an glibc-langpack-anp glibc-langpack-ar glibc-langpack-as glibc-langpack-ast glibc-langpack-ayc glibc-langpack-az glibc-langpack-be glibc-langpack-bem glibc-langpack-ber glibc-langpack-bg glibc-langpack-bhb glibc-langpack-bho glibc-langpack-bi glibc-langpack-bn glibc-langpack-bo glibc-langpack-br glibc-langpack-brx glibc-langpack-bs glibc-langpack-byn glibc-langpack-ca glibc-langpack-ce glibc-langpack-chr glibc-langpack-ckb glibc-langpack-cmn glibc-langpack-crh glibc-langpack-cs glibc-langpack-csb glibc-langpack-cv glibc-langpack-cy glibc-langpack-da glibc-langpack-de glibc-langpack-doi glibc-langpack-dsb glibc-langpack-dv glibc-langpack-dz glibc-langpack-el glibc-langpack-en glibc-langpack-eo glibc-langpack-es glibc-langpack-et glibc-langpack-eu glibc-langpack-fa glibc-langpack-ff glibc-langpack-fi glibc-langpack-fil glibc-langpack-fo glibc-langpack-fr glibc-langpack-fur glibc-langpack-fy glibc-langpack-ga glibc-langpack-gbm glibc-langpack-gd glibc-langpack-gez glibc-langpack-gl glibc-langpack-gu glibc-langpack-gv glibc-langpack-ha glibc-langpack-hak glibc-langpack-he glibc-langpack-hi glibc-langpack-hif glibc-langpack-hne glibc-langpack-hr glibc-langpack-hsb glibc-langpack-ht glibc-langpack-hu glibc-langpack-hy glibc-langpack-ia glibc-langpack-id glibc-langpack-ig glibc-langpack-ik glibc-langpack-is glibc-langpack-it glibc-langpack-iu glibc-langpack-ja glibc-langpack-ka glibc-langpack-kab glibc-langpack-kk glibc-langpack-kl glibc-langpack-km glibc-langpack-kn glibc-langpack-ko glibc-langpack-kok glibc-langpack-ks glibc-langpack-ku glibc-langpack-kv glibc-langpack-kw glibc-langpack-ky glibc-langpack-lb glibc-langpack-lg glibc-langpack-li glibc-langpack-lij glibc-langpack-ln glibc-langpack-lo glibc-langpack-lt glibc-langpack-lv glibc-langpack-lzh glibc-langpack-mag glibc-langpack-mai glibc-langpack-mfe glibc-langpack-mg glibc-langpack-mhr glibc-langpack-mi glibc-langpack-miq glibc-langpack-mjw glibc-langpack-mk glibc-langpack-ml glibc-langpack-mn glibc-langpack-mni glibc-langpack-mnw glibc-langpack-mr glibc-langpack-ms glibc-langpack-mt glibc-langpack-my glibc-langpack-nan glibc-langpack-nb glibc-langpack-nds glibc-langpack-ne glibc-langpack-nhn glibc-langpack-niu glibc-langpack-nl glibc-langpack-nn glibc-langpack-nr glibc-langpack-nso glibc-langpack-oc glibc-langpack-om glibc-langpack-or glibc-langpack-os glibc-langpack-pa glibc-langpack-pap glibc-langpack-pl glibc-langpack-ps glibc-langpack-pt glibc-langpack-quz glibc-langpack-raj glibc-langpack-rif glibc-langpack-ro glibc-langpack-ru glibc-langpack-rw glibc-langpack-sa glibc-langpack-sah glibc-langpack-sat glibc-langpack-sc glibc-langpack-sd glibc-langpack-se glibc-langpack-sgs glibc-langpack-shn glibc-langpack-shs glibc-langpack-si glibc-langpack-sid glibc-langpack-sk glibc-langpack-sl glibc-langpack-sm glibc-langpack-so glibc-langpack-sq glibc-langpack-sr glibc-langpack-ss glibc-langpack-ssy glibc-langpack-st glibc-langpack-su glibc-langpack-sv glibc-langpack-sw glibc-langpack-syr glibc-langpack-szl glibc-langpack-ta glibc-langpack-tcy glibc-langpack-te glibc-langpack-tg glibc-langpack-th glibc-langpack-the glibc-langpack-ti glibc-langpack-tig glibc-langpack-tk glibc-langpack-tl glibc-langpack-tn glibc-langpack-to glibc-langpack-tok glibc-langpack-tpi glibc-langpack-tr glibc-langpack-ts glibc-langpack-tt glibc-langpack-ug glibc-langpack-uk glibc-langpack-unm glibc-langpack-ur glibc-langpack-uz glibc-langpack-ve glibc-langpack-vi glibc-langpack-wa glibc-langpack-wae glibc-langpack-wal glibc-langpack-wo glibc-langpack-xh glibc-langpack-yi glibc-langpack-yo glibc-langpack-yue glibc-langpack-yuw glibc-langpack-zgh glibc-langpack-zh glibc-langpack-zu glibc-minimal-langpack libnsl glibc-devel glibc-doc glibc-locale-source glibc-utils glibc-benchtests glibc-nss-devel glibc-static nss_db nss_hesiod compat-libpthread-nonshared glibc32 sysroot-aarch64-el10-glibc sysroot-ppc64le-el10-glibc sysroot-s390x-el10-glibc sysroot-x86_64-el10-glibc"


URI_glibc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc = "basesystem ( ) libgcc(x86-64) ( ) glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-gconv-extra(x86-64) ( if  redhat-rpm-config)"
RPROVIDES:glibc = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) libc.so.6(GLIBC_2.34)(64bit) ( ) libm.so.6()(64bit) ( ) libm.so.6(GLIBC_2.2.5)(64bit) ( ) libc.so.6(GLIBC_2.4)(64bit) ( ) libc.so.6(GLIBC_2.14)(64bit) ( ) libm.so.6(GLIBC_2.29)(64bit) ( ) libm.so.6(GLIBC_2.38)(64bit) ( ) libresolv.so.2()(64bit) ( ) bundled(gnulib) ( ) libc.so.6(GLIBC_2.33)(64bit) ( ) libm.so.6(GLIBC_2.35)(64bit) ( ) ld-linux-x86-64.so.2()(64bit) ( ) libm.so.6(GLIBC_2.39)(64bit) ( ) libresolv.so.2(GLIBC_2.9)(64bit) ( ) ld-linux-x86-64.so.2(GLIBC_2.3)(64bit) ( ) libc.so.6(GLIBC_2.28)(64bit) ( ) libm.so.6(GLIBC_2.23)(64bit) ( ) libm.so.6(GLIBC_2.27)(64bit) ( ) libc.so.6(GLIBC_2.2.5)(64bit) ( ) libc.so.6(GLIBC_2.39)(64bit) ( ) libc.so.6(GLIBC_2.7)(64bit) ( ) /sbin/ldconfig ( ) libc.so.6(GLIBC_2.16)(64bit) ( ) libc.so.6(GLIBC_2.17)(64bit) ( ) libc.so.6(GLIBC_2.25)(64bit) ( ) libc.so.6(GLIBC_2.26)(64bit) ( ) libc.so.6(GLIBC_2.32)(64bit) ( ) libm.so.6(GLIBC_2.26)(64bit) ( ) libresolv.so.2(GLIBC_2.2.5)(64bit) ( ) /lib64/ld-linux-x86-64.so.2 ( ) /usr/sbin/ldconfig ( ) ld-linux-x86-64.so.2(GLIBC_2.2.5)(64bit) ( ) ld-linux-x86-64.so.2(GLIBC_2.34)(64bit) ( ) ld-linux-x86-64.so.2(GLIBC_2.35)(64bit) ( ) ld-linux-x86-64.so.2(GLIBC_2.4)(64bit) ( ) ld-linux-x86-64.so.2(GLIBC_PRIVATE)(64bit) ( ) ldconfig ( ) libBrokenLocale.so.1()(64bit) ( ) libBrokenLocale.so.1(GLIBC_2.2.5)(64bit) ( ) libanl.so.1()(64bit) ( ) libanl.so.1(GLIBC_2.2.5)(64bit) ( ) libc.so.6()(64bit) ( ) libc.so.6(GLIBC_2.10)(64bit) ( ) libc.so.6(GLIBC_2.11)(64bit) ( ) libc.so.6(GLIBC_2.12)(64bit) ( ) libc.so.6(GLIBC_2.13)(64bit) ( ) libc.so.6(GLIBC_2.15)(64bit) ( ) libc.so.6(GLIBC_2.18)(64bit) ( ) libc.so.6(GLIBC_2.2.6)(64bit) ( ) libc.so.6(GLIBC_2.22)(64bit) ( ) libc.so.6(GLIBC_2.23)(64bit) ( ) libc.so.6(GLIBC_2.24)(64bit) ( ) libc.so.6(GLIBC_2.27)(64bit) ( ) libc.so.6(GLIBC_2.29)(64bit) ( ) libc.so.6(GLIBC_2.3)(64bit) ( ) libc.so.6(GLIBC_2.3.2)(64bit) ( ) libc.so.6(GLIBC_2.3.3)(64bit) ( ) libc.so.6(GLIBC_2.3.4)(64bit) ( ) libc.so.6(GLIBC_2.30)(64bit) ( ) libc.so.6(GLIBC_2.31)(64bit) ( ) libc.so.6(GLIBC_2.35)(64bit) ( ) libc.so.6(GLIBC_2.36)(64bit) ( ) libc.so.6(GLIBC_2.5)(64bit) ( ) libc.so.6(GLIBC_2.6)(64bit) ( ) libc.so.6(GLIBC_2.8)(64bit) ( ) libc.so.6(GLIBC_2.9)(64bit) ( ) libc.so.6(GLIBC_ABI_DT_RELR)(64bit) ( ) libc.so.6(GLIBC_PRIVATE)(64bit) ( ) libdl.so.2()(64bit) ( ) libdl.so.2(GLIBC_2.2.5)(64bit) ( ) libdl.so.2(GLIBC_2.3.3)(64bit) ( ) libdl.so.2(GLIBC_2.3.4)(64bit) ( ) libm.so.6(GLIBC_2.15)(64bit) ( ) libm.so.6(GLIBC_2.18)(64bit) ( ) libm.so.6(GLIBC_2.24)(64bit) ( ) libm.so.6(GLIBC_2.25)(64bit) ( ) libm.so.6(GLIBC_2.28)(64bit) ( ) libm.so.6(GLIBC_2.31)(64bit) ( ) libm.so.6(GLIBC_2.32)(64bit) ( ) libm.so.6(GLIBC_2.4)(64bit) ( ) libmvec.so.1()(64bit) ( ) libmvec.so.1(GLIBC_2.22)(64bit) ( ) libmvec.so.1(GLIBC_2.35)(64bit) ( ) libnss_compat.so.2()(64bit) ( ) libnss_compat.so.2(GLIBC_PRIVATE)(64bit) ( ) libnss_dns.so.2()(64bit) ( ) libnss_dns.so.2(GLIBC_PRIVATE)(64bit) ( ) libnss_files.so.2()(64bit) ( ) libnss_files.so.2(GLIBC_PRIVATE)(64bit) ( ) libpcprofile.so()(64bit) ( ) libpthread.so.0()(64bit) ( ) libpthread.so.0(GLIBC_2.11)(64bit) ( ) libpthread.so.0(GLIBC_2.12)(64bit) ( ) libpthread.so.0(GLIBC_2.18)(64bit) ( ) libpthread.so.0(GLIBC_2.2.5)(64bit) ( ) libpthread.so.0(GLIBC_2.2.6)(64bit) ( ) libpthread.so.0(GLIBC_2.28)(64bit) ( ) libpthread.so.0(GLIBC_2.3.2)(64bit) ( ) libpthread.so.0(GLIBC_2.3.3)(64bit) ( ) libpthread.so.0(GLIBC_2.3.4)(64bit) ( ) libpthread.so.0(GLIBC_2.30)(64bit) ( ) libpthread.so.0(GLIBC_2.31)(64bit) ( ) libpthread.so.0(GLIBC_2.4)(64bit) ( ) libresolv.so.2(GLIBC_2.3.2)(64bit) ( ) libresolv.so.2(GLIBC_PRIVATE)(64bit) ( ) librt.so.1()(64bit) ( ) librt.so.1(GLIBC_2.2.5)(64bit) ( ) librt.so.1(GLIBC_2.3.3)(64bit) ( ) librt.so.1(GLIBC_2.3.4)(64bit) ( ) librt.so.1(GLIBC_2.4)(64bit) ( ) librt.so.1(GLIBC_2.7)(64bit) ( ) libthread_db.so.1()(64bit) ( ) libthread_db.so.1(GLIBC_2.2.5)(64bit) ( ) libthread_db.so.1(GLIBC_2.3)(64bit) ( ) libthread_db.so.1(GLIBC_2.3.3)(64bit) ( ) libutil.so.1()(64bit) ( ) libutil.so.1(GLIBC_2.2.5)(64bit) ( ) libc.so.6(GLIBC_ABI_DT_X86_64_PLT)(64bit) ( ) libc.so.6(GLIBC_ABI_GNU2_TLS)(64bit) ( ) glibc ( =  2.39-46.el10_0.4.alma.1) glibc(x86-64) ( =  2.39-46.el10_0.4.alma.1) config(glibc) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-all-langpacks = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-all-langpacks-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-all-langpacks = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-all-langpacks = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-all-langpacks ( =  2.39-46.el10_0.4.alma.1) glibc-all-langpacks(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-common-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-common = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) /usr/bin/bash ( ) ld-linux-x86-64.so.2()(64bit) ( ) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-common = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc-common(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-gconv-extra = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-gconv-extra-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-gconv-extra = "libc.so.6(GLIBC_2.4)(64bit) ( ) glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc(x86-64) ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-gconv-extra = "libCNS.so()(64bit) ( ) libGB.so()(64bit) ( ) libISOIR165.so()(64bit) ( ) libJIS.so()(64bit) ( ) libJISX0213.so()(64bit) ( ) libKSC.so()(64bit) ( ) glibc-gconv-extra(x86-64) ( =  2.39-46.el10_0.4.alma.1) config(glibc-gconv-extra) ( =  2.39-46.el10_0.4.alma.1) glibc-gconv-extra ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-aa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-aa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-aa = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-aa = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-aa ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-aa(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-af = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-af-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-af = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-af = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-af ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-af(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-agr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-agr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-agr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-agr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-agr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-agr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ak = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ak-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ak = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ak = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ak ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ak(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-am = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-am-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-am = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-am = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-am ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-am(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-an = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-an-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-an = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-an = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-an ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-an(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-anp = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-anp-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-anp = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-anp = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-anp ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-anp(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ar = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ar-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ar = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ar = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ar ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ar(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-as = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-as-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-as = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-as = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-as ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-as(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ast = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ast-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ast = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ast = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ast ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ast(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ayc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ayc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ayc = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ayc = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ayc ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ayc(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-az = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-az-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-az = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-az = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-az ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-az(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-be = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-be-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-be = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-be = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-be ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-be(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bem = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bem-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bem = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bem = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bem ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bem(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ber = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ber-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ber = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ber = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ber ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ber(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bg = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bg = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bg ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bg(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bhb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bhb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bhb = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bhb = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bhb ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bhb(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bho = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bho-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bho = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bho = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bho ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bho(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bo = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bo = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bo ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bo(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-br = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-br-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-br = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-br = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-br ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-br(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-brx = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-brx-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-brx = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-brx = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-brx ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-brx(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-bs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-bs = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-bs = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bs ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-bs(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-byn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-byn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-byn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-byn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-byn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-byn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ca = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ca-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ca = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ca = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ca ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ca(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ce = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ce-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ce = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ce = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ce ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ce(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-chr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-chr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-chr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-chr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-chr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-chr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ckb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ckb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ckb = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ckb = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ckb ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ckb(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-cmn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cmn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-cmn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-cmn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cmn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cmn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-crh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-crh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-crh = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-crh = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-crh ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-crh(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-cs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-cs = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-cs = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cs ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cs(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-csb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-csb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-csb = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-csb = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-csb ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-csb(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-cv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-cv = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-cv = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cv ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cv(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-cy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-cy = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-cy = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cy ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-cy(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-da = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-da-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-da = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-da = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-da ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-da(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-de = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-de-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-de = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-de = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-de ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-de(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-doi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-doi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-doi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-doi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-doi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-doi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-dsb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dsb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-dsb = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-dsb = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-dsb ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-dsb(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-dv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-dv = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-dv = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-dv ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-dv(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-dz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-dz = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-dz = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-dz ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-dz(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-el = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-el-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-el = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-el = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-el ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-el(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-en = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-en-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-en = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-en = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-en ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-en(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-eo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-eo = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-eo = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-eo ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-eo(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-es = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-es-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-es = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-es = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-es ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-es(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-et = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-et-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-et = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-et = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-et ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-et(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-eu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-eu = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-eu = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-eu ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-eu(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-fa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-fa = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-fa = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fa ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fa(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ff = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ff-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ff = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ff = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ff ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ff(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-fi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-fi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-fi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-fil = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fil-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-fil = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-fil = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fil ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fil(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-fo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-fo = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-fo = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fo ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fo(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-fr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-fr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-fr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-fur = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fur-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-fur = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-fur = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fur ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fur(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-fy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-fy = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-fy = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fy ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-fy(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ga = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ga-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ga = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ga = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ga ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ga(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-gbm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gbm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-gbm = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-gbm = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gbm ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gbm(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-gd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gd-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-gd = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-gd = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gd ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gd(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-gez = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gez-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-gez = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-gez = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gez ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gez(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-gl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-gl = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-gl = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gl ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-gu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-gu = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-gu = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gu ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gu(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-gv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-gv = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-gv = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gv ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-gv(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ha = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ha-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ha = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ha = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ha ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ha(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hak = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hak-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hak = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hak = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hak ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hak(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-he = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-he-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-he = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-he = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-he ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-he(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hif = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hif-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hif = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hif = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hif ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hif(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hne = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hne-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hne = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hne = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hne ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hne(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hsb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hsb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hsb = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hsb = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hsb ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hsb(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ht = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ht-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ht = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ht = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ht ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ht(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hu = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hu = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hu ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hu(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-hy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-hy = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-hy = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hy ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-hy(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ia = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ia-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ia = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ia = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ia ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ia(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-id = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-id-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-id = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-id = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-id ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-id(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ig = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ig-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ig = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ig = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ig ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ig(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ik = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ik-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ik = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ik = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ik ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ik(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-is = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-is-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-is = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-is = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-is ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-is(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-it = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-it-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-it = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-it = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-it ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-it(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-iu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-iu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-iu = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-iu = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-iu ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-iu(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ja = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ja-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ja = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ja = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ja ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ja(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ka = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ka-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ka = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ka = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ka ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ka(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-kab = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kab-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-kab = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-kab = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kab ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kab(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-kk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-kk = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-kk = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kk ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kk(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-kl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-kl = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-kl = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kl ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-km = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-km-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-km = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-km = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-km ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-km(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-kn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-kn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-kn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ko = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ko-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ko = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ko = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ko ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ko(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-kok = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kok-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-kok = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-kok = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kok ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kok(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ks = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ks-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ks = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ks = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ks ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ks(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ku = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ku-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ku = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ku = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ku ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ku(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-kv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-kv = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-kv = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kv ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kv(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-kw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-kw = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-kw = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kw ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-kw(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ky = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ky-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ky = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ky = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ky ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ky(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-lb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-lb = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-lb = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lb ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lb(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-lg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-lg = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-lg = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lg ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lg(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-li = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-li-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-li = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-li = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-li ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-li(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-lij = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lij-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-lij = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-lij = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lij ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lij(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ln = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ln-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ln = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ln = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ln ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ln(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-lo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-lo = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-lo = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lo ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lo(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-lt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-lt = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-lt = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lt ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lt(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-lv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-lv = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-lv = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lv ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lv(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-lzh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lzh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-lzh = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-lzh = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lzh ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-lzh(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mag = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mag-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mag = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mag = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mag ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mag(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mai = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mai-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mai = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mai = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mai ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mai(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mfe = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mfe-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mfe = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mfe = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mfe ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mfe(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mg = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mg = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mg ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mg(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mhr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mhr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mhr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mhr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mhr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mhr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-miq = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-miq-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-miq = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-miq = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-miq ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-miq(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mjw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mjw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mjw = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mjw = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mjw ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mjw(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mk = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mk = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mk ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mk(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ml = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ml-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ml = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ml = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ml ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ml(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mni = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mni-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mni = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mni = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mni ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mni(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mnw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mnw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mnw = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mnw = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mnw ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mnw(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ms = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ms-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ms = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ms = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ms ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ms(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-mt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-mt = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-mt = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mt ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-mt(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-my = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-my-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-my = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-my = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-my ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-my(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nan = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nan-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nan = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nan = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nan ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nan(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nb = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nb = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nb ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nb(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nds = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nds-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nds = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nds = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nds ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nds(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ne = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ne-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ne = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ne = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ne ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ne(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nhn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nhn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nhn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nhn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nhn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nhn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-niu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-niu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-niu = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-niu = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-niu ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-niu(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nl = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nl = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nl ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-nso = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nso-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-nso = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-nso = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nso ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-nso(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-oc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-oc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-oc = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-oc = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-oc ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-oc(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-om = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-om-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-om = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-om = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-om ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-om(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-or = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-or-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-or = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-or = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-or ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-or(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-os = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-os-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-os = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-os = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-os ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-os(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-pa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-pa = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-pa = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pa ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pa(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-pap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pap-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-pap = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-pap = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pap ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pap(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-pl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-pl = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-pl = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pl ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ps = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ps-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ps = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ps = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ps ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ps(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-pt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-pt = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-pt = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pt ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-pt(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-quz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-quz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-quz = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-quz = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-quz ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-quz(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-raj = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-raj-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-raj = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-raj = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-raj ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-raj(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-rif = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rif-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-rif = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-rif = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-rif ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-rif(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ro = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ro-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ro = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ro = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ro ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ro(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ru = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ru-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ru = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ru = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ru ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ru(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-rw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-rw = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-rw = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-rw ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-rw(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sa = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sa = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sa ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sa(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sah = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sah-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sah = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sah = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sah ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sah(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sat-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sat = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sat = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sat ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sat(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sc = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sc = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sc ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sc(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sd-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sd = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sd = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sd ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sd(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-se = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-se-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-se = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-se = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-se ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-se(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sgs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sgs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sgs = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sgs = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sgs ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sgs(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-shn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-shn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-shn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-shn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-shn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-shs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-shs = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-shs = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-shs ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-shs(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-si = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-si-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-si = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-si = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-si ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-si(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sid-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sid = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sid = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sid ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sid(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sk = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sk = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sk ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sk(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sl = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sl = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sl ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sm = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sm = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sm ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sm(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-so = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-so-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-so = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-so = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-so ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-so(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sq = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sq-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sq = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sq = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sq ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sq(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ss = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ss-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ss = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ss = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ss ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ss(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ssy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ssy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ssy = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ssy = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ssy ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ssy(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-st = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-st-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-st = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-st = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-st ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-st(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-su = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-su-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-su = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-su = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-su ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-su(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sv = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sv = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sv ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sv(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-sw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-sw = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-sw = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sw ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-sw(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-syr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-syr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-syr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-syr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-syr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-syr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-szl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-szl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-szl = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-szl = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-szl ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-szl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ta = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ta-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ta = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ta = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ta ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ta(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tcy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tcy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tcy = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tcy = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tcy ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tcy(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-te = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-te-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-te = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-te = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-te ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-te(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tg = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tg = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tg ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tg(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-th = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-th-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-th = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-th = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-th ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-th(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-the = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-the-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-the = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-the = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-the ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-the(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ti = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ti-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ti = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ti = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ti ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ti(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tig = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tig-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tig = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tig = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tig ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tig(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tk = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tk = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tk ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tk(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tl = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tl = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tl ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tn = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tn = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tn ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tn(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-to = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-to-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-to = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-to = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-to ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-to(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tok = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tok-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tok = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tok = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tok ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tok(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tpi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tpi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tpi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tpi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tpi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tpi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tr = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tr = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tr ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tr(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ts-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ts = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ts = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ts ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ts(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-tt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-tt = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-tt = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tt ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-tt(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ug = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ug-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ug = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ug = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ug ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ug(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-uk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-uk = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-uk = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-uk ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-uk(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-unm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-unm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-unm = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-unm = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-unm ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-unm(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ur = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ur-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ur = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ur = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ur ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ur(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-uz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-uz = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-uz = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-uz ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-uz(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-ve = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ve-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-ve = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-ve = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ve ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-ve(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-vi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-vi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-vi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-vi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-vi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-vi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-wa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-wa = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-wa = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wa ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wa(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-wae = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wae-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-wae = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-wae = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wae ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wae(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-wal = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wal-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-wal = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-wal = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wal ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wal(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-wo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-wo = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-wo = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wo ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-wo(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-xh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-xh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-xh = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-xh = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-xh ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-xh(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-yi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-yi = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-yi = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yi ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yi(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-yo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-yo = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-yo = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yo ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yo(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-yue = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yue-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-yue = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-yue = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yue ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yue(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-yuw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yuw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-yuw = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-yuw = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yuw ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-yuw(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-zgh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zgh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-zgh = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-zgh = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-zgh ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-zgh(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-zh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-zh = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-zh = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-zh ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-zh(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-langpack-zu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-langpack-zu = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-langpack-zu = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-zu ( =  2.39-46.el10_0.4.alma.1) glibc-langpack-zu(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-minimal-langpack = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-minimal-langpack-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-minimal-langpack = "glibc-common ( =  2.39-46.el10_0.4.alma.1) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-minimal-langpack = "glibc-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-minimal-langpack ( =  2.39-46.el10_0.4.alma.1) glibc-minimal-langpack(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_libnsl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnsl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:libnsl = "libc.so.6(GLIBC_2.38)(64bit) ( ) glibc(x86-64) ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:libnsl = "libnsl.so.1()(64bit) ( ) libnsl.so.1(GLIBC_2.2.5)(64bit) ( ) libnsl.so.1(GLIBC_PRIVATE)(64bit) ( ) libnsl ( =  2.39-46.el10_0.4.alma.1) libnsl(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-devel-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-devel = "libresolv.so.2()(64bit) ( ) libmvec.so.1()(64bit) ( ) libBrokenLocale.so.1()(64bit) ( ) libanl.so.1()(64bit) ( ) libthread_db.so.1()(64bit) ( ) glibc ( =  2.39-46.el10_0.4.alma.1) kernel-headers ( >=  3.2) libxcrypt-devel(x86-64) ( >=  4.0.0)"
RPROVIDES:glibc-devel = "glibc-headers(x86_64_v2) ( ) glibc-devel ( =  2.39-46.el10_0.4.alma.1) glibc-devel(x86-64) ( =  2.39-46.el10_0.4.alma.1) glibc-headers ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-doc-2.39-46.el10_0.4.alma.1.noarch.rpm;unpack=0"
RDEPENDS:glibc-doc = "glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-doc = "glibc-doc ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-locale-source = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-locale-source-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-locale-source = "glibc ( =  2.39-46.el10_0.4.alma.1) glibc-common ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-locale-source = "glibc-locale-source ( =  2.39-46.el10_0.4.alma.1) glibc-locale-source(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-utils-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-utils = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) libm.so.6()(64bit) ( ) /usr/bin/sh ( ) libz.so.1()(64bit) ( ) /usr/bin/bash ( ) ld-linux-x86-64.so.2()(64bit) ( ) ld-linux-x86-64.so.2(GLIBC_2.3)(64bit) ( ) /usr/bin/perl ( ) libpng16.so.16()(64bit) ( ) libgd.so.3()(64bit) ( ) ld-linux-x86-64.so.2(GLIBC_PRIVATE)(64bit) ( ) glibc ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-utils = "libmemusage.so()(64bit) ( ) glibc-utils ( =  2.39-46.el10_0.4.alma.1) glibc-utils(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-benchtests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibc-benchtests-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-benchtests = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) libm.so.6()(64bit) ( ) libm.so.6(GLIBC_2.2.5)(64bit) ( ) libm.so.6(GLIBC_2.29)(64bit) ( ) /usr/bin/python3 ( ) /usr/bin/bash ( ) libm.so.6(GLIBC_2.38)(64bit) ( ) libm.so.6(GLIBC_2.35)(64bit) ( ) libm.so.6(GLIBC_2.27)(64bit) ( ) libm.so.6(GLIBC_2.23)(64bit) ( ) libm.so.6(GLIBC_2.25)(64bit) ( ) libm.so.6(GLIBC_2.26)(64bit) ( ) libm.so.6(GLIBC_2.32)(64bit) ( ) libm.so.6(GLIBC_2.39)(64bit) ( ) libmvec.so.1()(64bit) ( ) libmvec.so.1(GLIBC_2.22)(64bit) ( ) libmvec.so.1(GLIBC_2.35)(64bit) ( )"
RPROVIDES:glibc-benchtests = "glibc-benchtests ( =  2.39-46.el10_0.4.alma.1) glibc-benchtests(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-nss-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibc-nss-devel-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-nss-devel = "libnss_db.so.2()(64bit) ( ) libnss_hesiod.so.2()(64bit) ( ) libnss_compat.so.2()(64bit) ( ) glibc(x86-64) ( =  2.39-46.el10_0.4.alma.1) nss_db(x86-64) ( =  2.39-46.el10_0.4.alma.1) nss_hesiod(x86-64) ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-nss-devel = "glibc-nss-devel ( =  2.39-46.el10_0.4.alma.1) glibc-nss-devel(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibc-static-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc-static = "libxcrypt-static(x86-64) ( >=  4.0.0) glibc-devel ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:glibc-static = "glibc-static ( =  2.39-46.el10_0.4.alma.1) glibc-static(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_nss_db = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nss_db-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:nss_db = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) libselinux.so.1()(64bit) ( ) libselinux.so.1(LIBSELINUX_1.0)(64bit) ( ) glibc(x86-64) ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:nss_db = "libnss_db.so.2()(64bit) ( ) libnss_db.so.2(GLIBC_PRIVATE)(64bit) ( ) nss_db(x86-64) ( =  2.39-46.el10_0.4.alma.1) nss_db ( =  2.39-46.el10_0.4.alma.1)"

URI_nss_hesiod = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nss_hesiod-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:nss_hesiod = "libc.so.6(GLIBC_2.38)(64bit) ( ) libresolv.so.2()(64bit) ( ) libresolv.so.2(GLIBC_2.9)(64bit) ( ) libnss_files.so.2()(64bit) ( ) glibc(x86-64) ( =  2.39-46.el10_0.4.alma.1)"
RPROVIDES:nss_hesiod = "libnss_hesiod.so.2()(64bit) ( ) libnss_hesiod.so.2(GLIBC_PRIVATE)(64bit) ( ) nss_hesiod(x86-64) ( =  2.39-46.el10_0.4.alma.1) nss_hesiod ( =  2.39-46.el10_0.4.alma.1)"

URI_compat-libpthread-nonshared = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/compat-libpthread-nonshared-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:compat-libpthread-nonshared = ""
RPROVIDES:compat-libpthread-nonshared = "compat-libpthread-nonshared ( =  2.39-46.el10_0.4.alma.1) compat-libpthread-nonshared(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_glibc32 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/glibc32-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;unpack=0"
RDEPENDS:glibc32 = ""
RPROVIDES:glibc32 = "glibc32 ( =  2.39-46.el10_0.4.alma.1) glibc32(x86-64) ( =  2.39-46.el10_0.4.alma.1)"

URI_sysroot-aarch64-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-aarch64-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;unpack=0"
RDEPENDS:sysroot-aarch64-el10-glibc = ""
RPROVIDES:sysroot-aarch64-el10-glibc = "sysroot-aarch64-glibc ( ) sysroot-aarch64-el10-glibc ( =  2.39-46.el10_0.4.alma.1)"

URI_sysroot-ppc64le-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-ppc64le-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;unpack=0"
RDEPENDS:sysroot-ppc64le-el10-glibc = ""
RPROVIDES:sysroot-ppc64le-el10-glibc = "sysroot-ppc64le-glibc ( ) sysroot-ppc64le-el10-glibc ( =  2.39-46.el10_0.4.alma.1)"

URI_sysroot-s390x-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-s390x-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;unpack=0"
RDEPENDS:sysroot-s390x-el10-glibc = ""
RPROVIDES:sysroot-s390x-el10-glibc = "sysroot-s390x-glibc ( ) sysroot-s390x-el10-glibc ( =  2.39-46.el10_0.4.alma.1)"

URI_sysroot-x86_64-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-x86_64-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;unpack=0"
RDEPENDS:sysroot-x86_64-el10-glibc = ""
RPROVIDES:sysroot-x86_64-el10-glibc = "sysroot-x86_64-glibc ( ) sysroot-x86_64-el10-glibc ( =  2.39-46.el10_0.4.alma.1)"
