
PN = "hyphen-uk"
PE = "0"
PV = "0.20030903"
PR = "32.el10"
PACKAGES = "hyphen-uk"


URI_hyphen-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-uk-0.20030903-32.el10.noarch.rpm;unpack=0"
RDEPENDS:hyphen-uk = "
 hyphen
"
