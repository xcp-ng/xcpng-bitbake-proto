
PN = "libieee1284"
PE = "0"
PV = "0.2.11"
PR = "46.el10"
PACKAGES = "libieee1284 libieee1284-devel"


URI_libieee1284 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libieee1284-0.2.11-46.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:libieee1284 = "
 glibc
"

URI_libieee1284-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libieee1284-devel-0.2.11-46.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:libieee1284-devel = "
 libieee1284
"
