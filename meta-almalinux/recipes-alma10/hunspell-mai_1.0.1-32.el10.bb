
PN = "hunspell-mai"
PE = "0"
PV = "1.0.1"
PR = "32.el10"
PACKAGES = "hunspell-mai"


URI_hunspell-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mai-1.0.1-32.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-mai = " \
 hunspell-filesystem \
"
