
PN = "hunspell-nl"
PE = "0"
PV = "2.20.19"
PR = "15.el10"
PACKAGES = "hunspell-nl"


URI_hunspell-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-nl-2.20.19-15.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-nl = "hunspell ( )"
RPROVIDES:hunspell-nl = "hunspell-nl ( =  2.20.19-15.el10)"
