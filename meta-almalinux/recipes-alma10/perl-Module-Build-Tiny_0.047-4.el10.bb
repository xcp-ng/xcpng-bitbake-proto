
PN = "perl-Module-Build-Tiny"
PE = "0"
PV = "0.047"
PR = "4.el10"
PACKAGES = "perl-Module-Build-Tiny"


URI_perl-Module-Build-Tiny = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Build-Tiny-0.047-4.el10.noarch.rpm;unpack=0"
RDEPENDS:perl-Module-Build-Tiny = "perl(strict) ( ) perl(warnings) ( ) perl-libs ( ) perl(File::Path) ( ) perl(File::Basename) ( ) perl(File::Spec::Functions) ( ) perl(File::Find) ( ) perl(DynaLoader) ( ) perl(CPAN::Meta) ( ) perl(ExtUtils::CBuilder) ( ) perl(Pod::Man) ( ) perl(TAP::Harness::Env) ( ) perl(ExtUtils::Install) ( ) perl(ExtUtils::ParseXS) ( ) perl(Exporter) ( >=  5.57) perl(ExtUtils::Config) ( >=  0.003) perl(ExtUtils::Helpers) ( >=  0.020) perl(ExtUtils::InstallPaths) ( >=  0.002) perl(Getopt::Long) ( >=  2.36) perl(JSON::PP) ( >=  2)"
RPROVIDES:perl-Module-Build-Tiny = "perl(Module::Build::Tiny) ( =  0.047) perl-Module-Build-Tiny ( =  0.047-4.el10)"
