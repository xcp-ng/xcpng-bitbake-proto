
PN = "osinfo-db-tools"
PE = "0"
PV = "1.11.0"
PR = "8.el10"
PACKAGES = "osinfo-db-tools"


URI_osinfo-db-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osinfo-db-tools-1.11.0-8.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:osinfo-db-tools = "rtld(GNU_HASH) ( ) libgcc_s.so.1()(64bit) ( ) libgcc_s.so.1(GCC_3.0)(64bit) ( ) libgcc_s.so.1(GCC_3.3.1)(64bit) ( ) libc.so.6(GLIBC_2.34)(64bit) ( ) libglib-2.0.so.0()(64bit) ( ) libgobject-2.0.so.0()(64bit) ( ) libgio-2.0.so.0()(64bit) ( ) libxml2.so.2()(64bit) ( ) libxml2.so.2(LIBXML2_2.4.30)(64bit) ( ) libxml2.so.2(LIBXML2_2.6.0)(64bit) ( ) libjson-glib-1.0.so.0()(64bit) ( ) libjson-glib-1.0.so.0(libjson-glib-1.0.so.0)(64bit) ( ) libarchive.so.13()(64bit) ( ) libsoup-3.0.so.0()(64bit) ( ) libxml2.so.2(LIBXML2_2.5.2)(64bit) ( )"
RPROVIDES:osinfo-db-tools = "osinfo-db-tools ( =  1.11.0-8.el10) osinfo-db-tools(x86-64) ( =  1.11.0-8.el10)"
