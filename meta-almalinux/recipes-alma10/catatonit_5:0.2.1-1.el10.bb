
inherit dnf-bridge

PN = "catatonit"
PE = "5"
PV = "0.2.1"
PR = "1.el10"
PACKAGES = "catatonit"


URI_catatonit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/catatonit-0.2.1-1.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:catatonit = ""
