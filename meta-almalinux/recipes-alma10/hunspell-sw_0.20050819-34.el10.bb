
PN = "hunspell-sw"
PE = "0"
PV = "0.20050819"
PR = "34.el10"
PACKAGES = "hunspell-sw"


URI_hunspell-sw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-sw-0.20050819-34.el10.noarch.rpm;unpack=0"
RDEPENDS:hunspell-sw = " \
 hunspell-filesystem \
"
