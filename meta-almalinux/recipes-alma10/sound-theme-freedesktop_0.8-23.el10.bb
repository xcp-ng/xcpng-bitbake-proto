
PN = "sound-theme-freedesktop"
PE = "0"
PV = "0.8"
PR = "23.el10"
PACKAGES = "sound-theme-freedesktop"


URI_sound-theme-freedesktop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sound-theme-freedesktop-0.8-23.el10.noarch.rpm;unpack=0"
RDEPENDS:sound-theme-freedesktop = " \
 coreutils \
 bash \
"
