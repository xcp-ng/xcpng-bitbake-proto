
PN = "hyphen-ku"
PE = "0"
PV = "1.71.2"
PR = "31.el10"
PACKAGES = "hyphen-ku"


URI_hyphen-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-ku-1.71.2-31.el10.noarch.rpm;unpack=0"
RDEPENDS:hyphen-ku = "hyphen ( )"
RPROVIDES:hyphen-ku = "hyphen-ku ( =  1.71.2-31.el10)"
