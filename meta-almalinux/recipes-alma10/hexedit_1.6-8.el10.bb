
PN = "hexedit"
PE = "0"
PV = "1.6"
PR = "8.el10"
PACKAGES = "hexedit"


URI_hexedit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hexedit-1.6-8.el10.x86_64_v2.rpm;unpack=0"
RDEPENDS:hexedit = "rtld(GNU_HASH) ( ) libc.so.6(GLIBC_2.38)(64bit) ( ) libtinfo.so.6()(64bit) ( ) libncurses.so.6()(64bit) ( )"
RPROVIDES:hexedit = "hexedit ( =  1.6-8.el10) hexedit(x86-64) ( =  1.6-8.el10)"
