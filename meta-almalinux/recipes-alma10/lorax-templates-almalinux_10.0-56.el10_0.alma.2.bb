
PN = "lorax-templates-almalinux"
PE = "0"
PV = "10.0"
PR = "56.el10_0.alma.2"
PACKAGES = "lorax-templates-almalinux"


URI_lorax-templates-almalinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-templates-almalinux-10.0-56.el10_0.alma.2.noarch.rpm;unpack=0"
RDEPENDS:lorax-templates-almalinux = "lorax ( >=  34.9.1)"
RPROVIDES:lorax-templates-almalinux = "lorax-templates ( =  10.0-56.el10_0.alma.2) lorax-templates-almalinux ( =  10.0-56.el10_0.alma.2)"
