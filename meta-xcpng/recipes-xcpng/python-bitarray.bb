inherit xcp-ng-rpm

SRCREV = "77d842106cc7fa953d51947db8c161fbe2b09248"
