inherit xcp-ng-rpm

SRCREV = "611e7cdfd15eb40442638352e2daf570223ce95d"
