inherit xcp-ng-rpm

SRCREV = "1294e3f154cbd5465d3ca276de3c35cb78468b94"
