inherit xcp-ng-rpm

SRCREV = "8cfc723f680f74deaa5a9ff412146c1df9974878"

# FIXME: needs COMPATIBLE_MACHINE restriction
