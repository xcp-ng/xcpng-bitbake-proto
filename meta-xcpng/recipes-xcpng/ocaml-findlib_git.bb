inherit xcp-ng-rpm

SRCREV = "5bbcde9f16cf8e9e50043e95fc39fa63986bc15d"

DEPENDS += "ocaml"

RDEPENDS = "ocaml"
