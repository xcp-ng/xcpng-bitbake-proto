inherit xcp-ng-rpm

SRCREV = "d85a9e633673d21edc7bf0896ab390627164c845"

DEPENDS += "ocaml xen xs-opam-repo"

RDEPENDS = "xen"
