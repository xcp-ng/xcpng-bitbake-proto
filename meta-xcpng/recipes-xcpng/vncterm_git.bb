inherit xcp-ng-rpm

SRCREV = "383229b2baba95162b6e5c97869a3a70f00ba69b"

DEPENDS += "xen"

RDEPENDS = "xen qemu"
