inherit xcp-ng-rpm

SRCREV = "bc9a5c76b9dc08f35995aad55d8c235463a0cb3e"
