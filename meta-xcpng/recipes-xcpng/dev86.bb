inherit xcp-ng-rpm

SRCREV = "28a144834093fb285ded4af7e0a08093ebfb65d5"
