inherit xcp-ng-rpm

SRCREV = "298d65894ec7d1a84827e100bb463b4d80ef8e5b"

DEPENDS += "xen xcp-efivar-utils"

RDEPENDS = "xapi xcp-efivar-utils"
