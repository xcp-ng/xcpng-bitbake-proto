inherit xcp-ng-rpm

REPONAME = "xcp-emu-manager"
SRCREV = "f6843abe70a4ebcb8ee94d4aa6a7cbe3593546c1"

DEPENDS += "libempserver xcp-ng-generic-lib"

RDEPENDS = "libempserver xcp-ng-generic-lib"
