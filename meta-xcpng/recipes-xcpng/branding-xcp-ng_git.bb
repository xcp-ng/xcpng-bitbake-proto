inherit xcp-ng-rpm

SRCREV = "d112cafc5b164b315efe1ec806f666bb457a606d"

# do not pull xcp-ng-release
PACKAGE_NEEDS_BOOTSTRAP = "1"
