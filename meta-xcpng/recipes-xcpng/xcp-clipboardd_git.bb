inherit xcp-ng-rpm

SRCREV = "3b41cd9e0bfc0b1e7bc2f8e1efef4ac009b204dc"

DEPENDS += "xen"

RDEPENDS = "xen"
