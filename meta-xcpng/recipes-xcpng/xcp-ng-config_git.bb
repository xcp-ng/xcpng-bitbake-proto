inherit xcp-ng-rpm

SRCREV = "c4e91a47b9b24369be72aeba0d2976240de2b24a"
