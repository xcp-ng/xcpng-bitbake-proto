inherit xcp-ng-rpm

SRCREV = "619494e5a0d4740a4ce52a44037b479c42470a6a"
