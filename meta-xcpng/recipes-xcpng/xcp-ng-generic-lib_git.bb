inherit xcp-ng-rpm

SRCREV = "a660ce38d96b8a3fa11fd8aedf523ada31711e38"
