inherit xcp-ng-rpm

SRCREV = "51c13423c36f32efe0f9a24494b6d843569aaf13"
