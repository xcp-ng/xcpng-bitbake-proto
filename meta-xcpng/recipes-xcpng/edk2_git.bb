inherit xcp-ng-rpm

SRCREV = "51d8fa17a1b06a7a5e39f2652a4150d08307705c"

DEPENDS += "ipxe"
