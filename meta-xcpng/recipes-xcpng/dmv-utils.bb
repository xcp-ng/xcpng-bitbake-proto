inherit xcp-ng-rpm

SRCREV = "95f4082a913826a26e894fb761d6882023c1750c"

RDEPENDS = "xcp-python-libs"
