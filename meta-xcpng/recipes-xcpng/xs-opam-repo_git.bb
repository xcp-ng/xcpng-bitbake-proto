inherit xcp-ng-rpm

SRCREV = "34b3f33a4391c999a1a83783ed1d46e049c9a51e"

DEPENDS += "ocaml opam xs-opam-src"

RDEPENDS = "ocaml opam"
