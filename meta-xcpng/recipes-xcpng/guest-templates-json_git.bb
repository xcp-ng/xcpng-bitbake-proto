inherit xcp-ng-rpm

SRCREV = "5c1cf04160d3b2b7619d46b59f098f88ca1c7504"

RDEPENDS = "xapi"
