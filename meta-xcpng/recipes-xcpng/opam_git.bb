inherit xcp-ng-rpm

SRCREV = "e499b424da06d894a897aac6ceb3ce4747e13792"

DEPENDS += "ocaml"
